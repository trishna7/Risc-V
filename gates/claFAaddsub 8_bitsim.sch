v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
B 2 2378 -2473 3178 -2073 {flags=graph
y1=0
y2=2
ypos1=-0.41094532
ypos2=1.5890548

subdivy=1
unity=1
x1=-8.0826191e-09
x2=9.1917371e-08


xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
divx=10
divy=5
subdivx=1
digital=1


color="11 11 11"
node="a;a3,a2,a1,a0,a3,a2,a1,a0
b;b3,b2,b1,b0,b3,b2,b1,b0
s;cout,s7,s6,s5,s4,s3,s2,s1,s0"}
B 2 3688 -2503 4488 -2103 {flags=graph
y1=0
y2=2
ypos1=-0.11094529
ypos2=1.8890548

subdivy=1
unity=1
x1=-8.0826191e-09
x2=9.1917371e-08


xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
divx=10
divy=5
subdivx=1
digital=1



color="4 4 4 4 4 4 4 4"
node="s7
s6
s5
s4
s3
s2
s1
s0"}
N 1850 -1470 1850 -1440 {
lab=#net1}
N 1850 -1440 1910 -1440 {
lab=#net1}
N 1850 -1420 1850 -1380 {
lab=#net2}
N 1850 -1420 1910 -1420 {
lab=#net2}
N 1660 -1650 1720 -1650 {
lab=Cin}
N 1660 -1650 1660 -1490 {
lab=Cin}
N 1660 -1490 1660 -1480 {
lab=Cin}
N 1660 -1480 1720 -1480 {
lab=Cin}
N 1630 -1460 1720 -1460 {
lab=#net3}
N 1630 -1670 1630 -1460 {
lab=#net3}
N 1630 -1670 1720 -1670 {
lab=#net3}
N 1570 -1670 1630 -1670 {
lab=#net3}
N 1800 -1470 1850 -1470 {
lab=#net1}
N 1800 -1380 1850 -1380 {
lab=#net2}
N 2040 -1430 2080 -1430 {
lab=Co1}
N 1860 -1660 1920 -1660 {
lab=S0}
N 1325 -1680 1430 -1680 {
lab=A0}
N 1325 -1660 1430 -1660 {
lab=#net4}
N 1385 -1390 1720 -1390 {
lab=A0}
N 1385 -1680 1385 -1390 {
lab=A0}
N 1355 -1370 1720 -1370 {
lab=#net4}
N 1355 -1660 1355 -1370 {
lab=#net4}
N 1330 -1480 1660 -1480 {
lab=Cin}
N 2710 -1470 2710 -1440 {
lab=#net5}
N 2710 -1440 2770 -1440 {
lab=#net5}
N 2710 -1420 2710 -1380 {
lab=#net6}
N 2710 -1420 2770 -1420 {
lab=#net6}
N 2520 -1650 2580 -1650 {
lab=#net7}
N 2520 -1650 2520 -1490 {
lab=#net7}
N 2520 -1490 2520 -1480 {
lab=#net7}
N 2520 -1480 2580 -1480 {
lab=#net7}
N 2490 -1460 2580 -1460 {
lab=#net8}
N 2490 -1670 2490 -1460 {
lab=#net8}
N 2490 -1670 2580 -1670 {
lab=#net8}
N 2430 -1670 2490 -1670 {
lab=#net8}
N 2660 -1470 2710 -1470 {
lab=#net5}
N 2660 -1380 2710 -1380 {
lab=#net6}
N 2900 -1430 2940 -1430 {
lab=Co2}
N 2720 -1660 2780 -1660 {
lab=S1}
N 2185 -1680 2290 -1680 {
lab=A1}
N 2185 -1660 2290 -1660 {
lab=#net9}
N 2245 -1390 2580 -1390 {
lab=A1}
N 2245 -1680 2245 -1390 {
lab=A1}
N 2215 -1370 2580 -1370 {
lab=#net9}
N 2215 -1660 2215 -1370 {
lab=#net9}
N 2190 -1480 2520 -1480 {
lab=#net7}
N 3620 -1480 3620 -1450 {
lab=#net10}
N 3620 -1450 3680 -1450 {
lab=#net10}
N 3620 -1430 3620 -1390 {
lab=#net11}
N 3620 -1430 3680 -1430 {
lab=#net11}
N 3430 -1660 3490 -1660 {
lab=#net12}
N 3430 -1660 3430 -1500 {
lab=#net12}
N 3430 -1500 3430 -1490 {
lab=#net12}
N 3430 -1490 3490 -1490 {
lab=#net12}
N 3400 -1470 3490 -1470 {
lab=#net13}
N 3400 -1680 3400 -1470 {
lab=#net13}
N 3400 -1680 3490 -1680 {
lab=#net13}
N 3340 -1680 3400 -1680 {
lab=#net13}
N 3570 -1480 3620 -1480 {
lab=#net10}
N 3570 -1390 3620 -1390 {
lab=#net11}
N 3810 -1440 3850 -1440 {
lab=Co3}
N 3630 -1670 3690 -1670 {
lab=S2}
N 3095 -1690 3200 -1690 {
lab=A2}
N 3095 -1670 3200 -1670 {
lab=#net14}
N 3155 -1400 3490 -1400 {
lab=A2}
N 3155 -1690 3155 -1400 {
lab=A2}
N 3125 -1380 3490 -1380 {
lab=#net14}
N 3125 -1670 3125 -1380 {
lab=#net14}
N 3100 -1490 3430 -1490 {
lab=#net12}
N 4270 -1640 4330 -1640 {
lab=#net15}
N 4270 -1640 4270 -1480 {
lab=#net15}
N 4270 -1480 4270 -1470 {
lab=#net15}
N 4270 -1470 4330 -1470 {
lab=#net15}
N 4240 -1450 4330 -1450 {
lab=#net16}
N 4650 -1420 4690 -1420 {
lab=Co4}
N 4470 -1650 4530 -1650 {
lab=S3}
N 3935 -1670 4040 -1670 {
lab=A3}
N 3935 -1650 4040 -1650 {
lab=#net17}
N 3995 -1380 4330 -1380 {
lab=A3}
N 3995 -1670 3995 -1380 {
lab=A3}
N 3965 -1360 4330 -1360 {
lab=#net17}
N 3965 -1650 3965 -1360 {
lab=#net17}
N 3940 -1470 4270 -1470 {
lab=#net15}
N 1800 -1380 1800 -1020 {
lab=#net2}
N 1800 -1020 3090 -1020 {
lab=#net2}
N 3090 -1020 3090 -880 {
lab=#net2}
N 1630 -1460 1630 -990 {
lab=#net3}
N 1630 -990 2930 -990 {
lab=#net3}
N 2930 -990 2930 -880 {
lab=#net3}
N 2490 -1460 2490 -960 {
lab=#net8}
N 2490 -960 2940 -960 {
lab=#net8}
N 2940 -960 2950 -960 {
lab=#net8}
N 2950 -960 2950 -880 {
lab=#net8}
N 2690 -1380 2690 -1050 {
lab=#net6}
N 2690 -1050 3060 -1050 {
lab=#net6}
N 3060 -1050 3070 -1050 {
lab=#net6}
N 3070 -1050 3070 -880 {
lab=#net6}
N 2970 -1130 2970 -880 {
lab=#net13}
N 2970 -1130 3400 -1130 {
lab=#net13}
N 3400 -1470 3400 -1130 {
lab=#net13}
N 3570 -1390 3570 -960 {
lab=#net11}
N 3050 -960 3570 -960 {
lab=#net11}
N 3050 -960 3050 -880 {
lab=#net11}
N 4240 -1450 4240 -920 {
lab=#net16}
N 2990 -920 4240 -920 {
lab=#net16}
N 2990 -920 2990 -880 {
lab=#net16}
N 1300 -810 2870 -810 {
lab=Cin}
N 1300 -1480 1300 -810 {
lab=Cin}
N 1300 -1480 1330 -1480 {
lab=Cin}
N 2190 -1480 2190 -690 {
lab=#net7}
N 2190 -690 3180 -690 {
lab=#net7}
N 3180 -830 3180 -690 {
lab=#net7}
N 3140 -830 3180 -830 {
lab=#net7}
N 3100 -1490 3100 -1170 {
lab=#net12}
N 3100 -1170 3260 -1170 {
lab=#net12}
N 3260 -1170 3260 -810 {
lab=#net12}
N 3140 -810 3260 -810 {
lab=#net12}
N 3140 -790 3950 -790 {
lab=#net15}
N 3950 -1470 3950 -790 {
lab=#net15}
N 3140 -770 3200 -770 {
lab=#net18}
N 4460 -1430 4520 -1430 {
lab=#net19}
N 4460 -1460 4460 -1430 {
lab=#net19}
N 4410 -1460 4460 -1460 {
lab=#net19}
N 4180 -1660 4330 -1660 {
lab=#net16}
N 4240 -1660 4240 -1450 {
lab=#net16}
N 4460 -1410 4520 -1410 {
lab=#net20}
N 4460 -1410 4460 -1370 {
lab=#net20}
N 4410 -1370 4460 -1370 {
lab=#net20}
N 4460 -1370 4460 -900 {
lab=#net20}
N 3030 -900 4460 -900 {
lab=#net20}
N 3030 -900 3030 -880 {
lab=#net20}
N 1100 -1760 1120 -1760 {
lab=B0}
N 1260 -1770 1350 -1770 {
lab=#net4}
N 1350 -1770 1350 -1660 {
lab=#net4}
N 2030 -1760 2070 -1760 {
lab=B1}
N 2210 -1770 2210 -1660 {
lab=#net9}
N 3090 -1770 3110 -1770 {
lab=#net14}
N 3110 -1770 3110 -1670 {
lab=#net14}
N 2920 -1760 2950 -1760 {
lab=B2}
N 3930 -1760 3960 -1760 {
lab=#net17}
N 3960 -1760 3960 -1650 {
lab=#net17}
N 3760 -1750 3790 -1750 {
lab=B3}
N 3710 -1770 3790 -1770 {
lab=Cin}
N 3710 -1840 3710 -1770 {
lab=Cin}
N 2920 -1840 3710 -1840 {
lab=Cin}
N 2920 -1840 2920 -1780 {
lab=Cin}
N 2920 -1780 2950 -1780 {
lab=Cin}
N 1990 -1840 2920 -1840 {
lab=Cin}
N 1990 -1840 1990 -1790 {
lab=Cin}
N 1990 -1790 1990 -1780 {
lab=Cin}
N 1990 -1780 2070 -1780 {
lab=Cin}
N 1090 -1840 1990 -1840 {
lab=Cin}
N 1090 -1840 1090 -1780 {
lab=Cin}
N 1090 -1780 1120 -1780 {
lab=Cin}
N 1000 -1840 1090 -1840 {
lab=Cin}
N 1000 -1840 1000 -1560 {
lab=Cin}
N 1000 -1560 1300 -1560 {
lab=Cin}
N 1300 -1560 1300 -1480 {
lab=Cin}
N 5580 -1480 5580 -1450 {
lab=#net21}
N 5580 -1450 5640 -1450 {
lab=#net21}
N 5580 -1430 5580 -1390 {
lab=#net22}
N 5580 -1430 5640 -1430 {
lab=#net22}
N 5390 -1660 5450 -1660 {
lab=#net18}
N 5390 -1660 5390 -1500 {
lab=#net18}
N 5390 -1500 5390 -1490 {
lab=#net18}
N 5390 -1490 5450 -1490 {
lab=#net18}
N 5360 -1470 5450 -1470 {
lab=#net23}
N 5360 -1680 5360 -1470 {
lab=#net23}
N 5360 -1680 5450 -1680 {
lab=#net23}
N 5300 -1680 5360 -1680 {
lab=#net23}
N 5530 -1480 5580 -1480 {
lab=#net21}
N 5530 -1390 5580 -1390 {
lab=#net22}
N 5770 -1440 5810 -1440 {
lab=Co5}
N 5590 -1670 5650 -1670 {
lab=S4}
N 5055 -1690 5160 -1690 {
lab=A0}
N 5055 -1670 5160 -1670 {
lab=#net24}
N 5115 -1400 5450 -1400 {
lab=A0}
N 5115 -1690 5115 -1400 {
lab=A0}
N 5085 -1380 5450 -1380 {
lab=#net24}
N 5085 -1670 5085 -1380 {
lab=#net24}
N 5060 -1490 5390 -1490 {
lab=#net18}
N 6440 -1480 6440 -1450 {
lab=#net25}
N 6440 -1450 6500 -1450 {
lab=#net25}
N 6440 -1430 6440 -1390 {
lab=#net26}
N 6440 -1430 6500 -1430 {
lab=#net26}
N 6250 -1660 6310 -1660 {
lab=#net27}
N 6250 -1660 6250 -1500 {
lab=#net27}
N 6250 -1500 6250 -1490 {
lab=#net27}
N 6250 -1490 6310 -1490 {
lab=#net27}
N 6220 -1470 6310 -1470 {
lab=#net28}
N 6220 -1680 6220 -1470 {
lab=#net28}
N 6220 -1680 6310 -1680 {
lab=#net28}
N 6160 -1680 6220 -1680 {
lab=#net28}
N 6390 -1480 6440 -1480 {
lab=#net25}
N 6390 -1390 6440 -1390 {
lab=#net26}
N 6630 -1440 6670 -1440 {
lab=Co6}
N 6450 -1670 6510 -1670 {
lab=S5}
N 5915 -1690 6020 -1690 {
lab=A1}
N 5915 -1670 6020 -1670 {
lab=#net29}
N 5975 -1400 6310 -1400 {
lab=A1}
N 5975 -1690 5975 -1400 {
lab=A1}
N 5945 -1380 6310 -1380 {
lab=#net29}
N 5945 -1670 5945 -1380 {
lab=#net29}
N 5920 -1490 6250 -1490 {
lab=#net27}
N 7350 -1490 7350 -1460 {
lab=#net30}
N 7350 -1460 7410 -1460 {
lab=#net30}
N 7350 -1440 7350 -1400 {
lab=#net31}
N 7350 -1440 7410 -1440 {
lab=#net31}
N 7160 -1670 7220 -1670 {
lab=#net32}
N 7160 -1670 7160 -1510 {
lab=#net32}
N 7160 -1510 7160 -1500 {
lab=#net32}
N 7160 -1500 7220 -1500 {
lab=#net32}
N 7130 -1480 7220 -1480 {
lab=#net33}
N 7130 -1690 7130 -1480 {
lab=#net33}
N 7130 -1690 7220 -1690 {
lab=#net33}
N 7070 -1690 7130 -1690 {
lab=#net33}
N 7300 -1490 7350 -1490 {
lab=#net30}
N 7300 -1400 7350 -1400 {
lab=#net31}
N 7540 -1450 7580 -1450 {
lab=Co7}
N 7360 -1680 7420 -1680 {
lab=S6}
N 6825 -1700 6930 -1700 {
lab=A2}
N 6825 -1680 6930 -1680 {
lab=#net34}
N 6885 -1410 7220 -1410 {
lab=A2}
N 6885 -1700 6885 -1410 {
lab=A2}
N 6855 -1390 7220 -1390 {
lab=#net34}
N 6855 -1680 6855 -1390 {
lab=#net34}
N 6830 -1500 7160 -1500 {
lab=#net32}
N 8000 -1650 8060 -1650 {
lab=#net35}
N 8000 -1650 8000 -1490 {
lab=#net35}
N 8000 -1490 8000 -1480 {
lab=#net35}
N 8000 -1480 8060 -1480 {
lab=#net35}
N 7970 -1460 8060 -1460 {
lab=#net36}
N 8380 -1430 8420 -1430 {
lab=Co8}
N 8200 -1660 8260 -1660 {
lab=S7}
N 7665 -1680 7770 -1680 {
lab=A3}
N 7665 -1660 7770 -1660 {
lab=#net37}
N 7725 -1390 8060 -1390 {
lab=A3}
N 7725 -1680 7725 -1390 {
lab=A3}
N 7695 -1370 8060 -1370 {
lab=#net37}
N 7695 -1660 7695 -1370 {
lab=#net37}
N 7670 -1480 8000 -1480 {
lab=#net35}
N 5530 -1390 5530 -1030 {
lab=#net22}
N 5530 -1030 6820 -1030 {
lab=#net22}
N 6820 -1030 6820 -890 {
lab=#net22}
N 5360 -1470 5360 -1000 {
lab=#net23}
N 5360 -1000 6660 -1000 {
lab=#net23}
N 6660 -1000 6660 -890 {
lab=#net23}
N 6220 -1470 6220 -970 {
lab=#net28}
N 6220 -970 6670 -970 {
lab=#net28}
N 6670 -970 6680 -970 {
lab=#net28}
N 6680 -970 6680 -890 {
lab=#net28}
N 6420 -1390 6420 -1060 {
lab=#net26}
N 6420 -1060 6790 -1060 {
lab=#net26}
N 6790 -1060 6800 -1060 {
lab=#net26}
N 6800 -1060 6800 -890 {
lab=#net26}
N 6700 -1140 6700 -890 {
lab=#net33}
N 6700 -1140 7130 -1140 {
lab=#net33}
N 7130 -1480 7130 -1140 {
lab=#net33}
N 7300 -1400 7300 -970 {
lab=#net31}
N 6780 -970 7300 -970 {
lab=#net31}
N 6780 -970 6780 -890 {
lab=#net31}
N 7970 -1460 7970 -930 {
lab=#net36}
N 6720 -930 7970 -930 {
lab=#net36}
N 6720 -930 6720 -890 {
lab=#net36}
N 5030 -1490 5060 -1490 {
lab=#net18}
N 5920 -1490 5920 -700 {
lab=#net27}
N 5920 -700 6910 -700 {
lab=#net27}
N 6910 -840 6910 -700 {
lab=#net27}
N 6870 -840 6910 -840 {
lab=#net27}
N 6830 -1500 6830 -1180 {
lab=#net32}
N 6830 -1180 6990 -1180 {
lab=#net32}
N 6990 -1180 6990 -820 {
lab=#net32}
N 6870 -820 6990 -820 {
lab=#net32}
N 6870 -800 7680 -800 {
lab=#net35}
N 7680 -1480 7680 -800 {
lab=#net35}
N 6870 -780 6930 -780 {
lab=Cout}
N 8190 -1440 8250 -1440 {
lab=#net38}
N 8190 -1470 8190 -1440 {
lab=#net38}
N 8140 -1470 8190 -1470 {
lab=#net38}
N 7910 -1670 8060 -1670 {
lab=#net36}
N 7970 -1670 7970 -1460 {
lab=#net36}
N 8190 -1420 8250 -1420 {
lab=#net39}
N 8190 -1420 8190 -1380 {
lab=#net39}
N 8140 -1380 8190 -1380 {
lab=#net39}
N 8190 -1380 8190 -910 {
lab=#net39}
N 6760 -910 8190 -910 {
lab=#net39}
N 6760 -910 6760 -890 {
lab=#net39}
N 4830 -1770 4850 -1770 {
lab=B0}
N 4990 -1780 5080 -1780 {
lab=#net24}
N 5080 -1780 5080 -1670 {
lab=#net24}
N 5760 -1770 5800 -1770 {
lab=B1}
N 5940 -1780 5940 -1670 {
lab=#net29}
N 6820 -1780 6840 -1780 {
lab=#net34}
N 6840 -1780 6840 -1680 {
lab=#net34}
N 6650 -1770 6680 -1770 {
lab=B2}
N 7660 -1770 7690 -1770 {
lab=#net37}
N 7690 -1770 7690 -1660 {
lab=#net37}
N 7490 -1760 7520 -1760 {
lab=B3}
N 7440 -1780 7520 -1780 {
lab=Cin}
N 7440 -1850 7440 -1780 {
lab=Cin}
N 6650 -1850 7440 -1850 {
lab=Cin}
N 6650 -1850 6650 -1790 {
lab=Cin}
N 6650 -1790 6680 -1790 {
lab=Cin}
N 5720 -1850 6650 -1850 {
lab=Cin}
N 5720 -1850 5720 -1800 {
lab=Cin}
N 5720 -1800 5720 -1790 {
lab=Cin}
N 5720 -1790 5800 -1790 {
lab=Cin}
N 4820 -1850 5720 -1850 {
lab=Cin}
N 4820 -1850 4820 -1790 {
lab=Cin}
N 4820 -1790 4850 -1790 {
lab=Cin}
N 4730 -1850 4820 -1850 {
lab=Cin}
N 3200 -770 4910 -770 {
lab=#net18}
N 4910 -1490 4910 -770 {
lab=#net18}
N 4910 -1490 5030 -1490 {
lab=#net18}
N 3710 -1850 4740 -1850 {
lab=Cin}
N 3710 -1850 3710 -1830 {
lab=Cin}
N 4910 -820 6600 -820 {
lab=#net18}
N 7430 -1860 7430 -1850 {
lab=Cin}
C {XOR2.sym} 1490 -1670 0 0 {name=x1}
C {XOR2.sym} 1780 -1660 0 0 {name=x2}
C {OR2.sym} 1960 -1430 0 0 {name=x3}
C {AND2.sym} 1760 -1470 0 0 {name=x4}
C {AND2.sym} 1760 -1380 0 0 {name=x5}
C {devices/opin.sym} 1920 -1660 0 0 {name=p4 lab=S0}
C {devices/lab_pin.sym} 2080 -1430 2 0 {name=p5 lab=Co1}
C {devices/ipin.sym} 1325 -1680 0 0 {name=p1 sig_type=std_logic lab=A0}
C {devices/ipin.sym} 1105 -1760 0 0 {name=p2 sig_type=std_logic lab=B0}
C {devices/ipin.sym} 1300 -1480 0 0 {name=p3 sig_type=std_logic lab=Cin}
C {XOR2.sym} 2350 -1670 0 0 {name=x6}
C {XOR2.sym} 2640 -1660 0 0 {name=x7}
C {OR2.sym} 2820 -1430 0 0 {name=x8}
C {AND2.sym} 2620 -1470 0 0 {name=x9}
C {AND2.sym} 2620 -1380 0 0 {name=x10}
C {devices/opin.sym} 2780 -1660 0 0 {name=p8 lab=S1}
C {devices/ipin.sym} 2185 -1680 0 0 {name=p10 sig_type=std_logic lab=A1}
C {devices/ipin.sym} 2035 -1760 0 0 {name=p11 sig_type=std_logic lab=B1}
C {XOR2.sym} 3260 -1680 0 0 {name=x11}
C {XOR2.sym} 3550 -1670 0 0 {name=x12}
C {OR2.sym} 3730 -1440 0 0 {name=x13}
C {AND2.sym} 3530 -1480 0 0 {name=x14}
C {AND2.sym} 3530 -1390 0 0 {name=x15}
C {devices/opin.sym} 3690 -1670 0 0 {name=p17 lab=S2}
C {devices/ipin.sym} 3095 -1690 0 0 {name=p19 sig_type=std_logic lab=A2}
C {devices/ipin.sym} 2925 -1760 0 0 {name=p20 sig_type=std_logic lab=B2}
C {XOR2.sym} 4100 -1660 0 0 {name=x16}
C {XOR2.sym} 4390 -1650 0 0 {name=x17}
C {OR2.sym} 4570 -1420 0 0 {name=x18}
C {AND2.sym} 4370 -1460 0 0 {name=x19}
C {AND2.sym} 4370 -1370 0 0 {name=x20}
C {devices/opin.sym} 4530 -1650 0 0 {name=p24 lab=S3}
C {devices/ipin.sym} 3935 -1670 0 0 {name=p26 sig_type=std_logic lab=A3}
C {devices/ipin.sym} 3765 -1750 0 0 {name=p27 sig_type=std_logic lab=B3}
C {4_BIT_CLA_Carry_logic.sym} 2990 -780 0 0 {name=x21}
C {devices/lab_pin.sym} 2940 -1430 2 0 {name=p9 lab=Co2}
C {devices/lab_pin.sym} 3850 -1440 2 0 {name=p12 lab=Co3}
C {devices/lab_pin.sym} 4690 -1420 2 0 {name=p13 lab=Co4}
C {XOR2.sym} 1180 -1770 0 0 {name=x22}
C {XOR2.sym} 2130 -1770 0 0 {name=x23}
C {XOR2.sym} 3010 -1770 0 0 {name=x24}
C {XOR2.sym} 3850 -1760 0 0 {name=x25}
C {devices/vsource.sym} 3458 -2468 0 0 {name=VA4 value="pwl=0 1.8 50n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 3458 -2498 0 0 {name=p38 sig_type=std_logic lab=A3}
C {devices/vsource.sym} 3458 -2368 0 0 {name=VA5 value="pwl=0 1.8 50n 1.8 " savecurrent=false}
C {devices/lab_pin.sym} 3458 -2398 0 0 {name=p39 sig_type=std_logic lab=A2}
C {devices/vsource.sym} 3458 -2268 0 0 {name=VA6 value="pwl=0 0 50n 0 " savecurrent=false}
C {devices/lab_pin.sym} 3458 -2298 0 0 {name=p40 sig_type=std_logic lab=A1}
C {devices/vsource.sym} 3458 -2168 0 0 {name=VA0 value="pwl=0 1.8 50n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 3458 -2198 0 0 {name=VA7 sig_type=std_logic lab=A0}
C {devices/vsource.sym} 3238 -2478 0 0 {name=VB5 value="pwl=0 1.8 50n 1.8 " savecurrent=false}
C {devices/lab_pin.sym} 3238 -2508 0 0 {name=VB4 sig_type=std_logic lab=B3}
C {devices/vsource.sym} 3238 -2378 0 0 {name=VB6 value="pwl=0 1.8 50n 1.8 " savecurrent=false}
C {devices/lab_pin.sym} 3238 -2408 0 0 {name=VB7 sig_type=std_logic lab=B2}
C {devices/vsource.sym} 3238 -2278 0 0 {name=VB8 value="pwl=0 1.8 50n 1.8 " savecurrent=false}
C {devices/lab_pin.sym} 3238 -2308 0 0 {name=VB9 sig_type=std_logic lab=B1}
C {devices/vsource.sym} 3238 -2178 0 0 {name=VB0 value="pwl=0 1.8 50n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 3238 -2208 0 0 {name=VB10 sig_type=std_logic lab=B0}
C {devices/gnd.sym} 3458 -2138 0 0 {name=l7 lab=GND}
C {devices/gnd.sym} 3238 -2148 0 0 {name=l8 lab=GND}
C {devices/gnd.sym} 3458 -2238 0 0 {name=l15 lab=GND}
C {devices/gnd.sym} 3238 -2248 0 0 {name=l16 lab=GND}
C {devices/gnd.sym} 3458 -2338 0 0 {name=l17 lab=GND}
C {devices/gnd.sym} 3238 -2348 0 0 {name=l18 lab=GND}
C {devices/gnd.sym} 3238 -2448 0 0 {name=l19 lab=GND}
C {devices/gnd.sym} 3458 -2438 0 0 {name=l20 lab=GND}
C {devices/vsource.sym} 3458 -2048 0 0 {name=VCi value="pwl=0 1.8 50n 1.8 " savecurrent=false}
C {devices/lab_pin.sym} 3458 -2078 0 0 {name=Ci1 sig_type=std_logic lab=Cin}
C {devices/gnd.sym} 3458 -2018 0 0 {name=Ci2 lab=GND}
C {devices/vsource.sym} 3238 -2058 0 0 {name=VDD1 value=1.8 savecurrent=false}
C {devices/lab_pin.sym} 3238 -2088 0 0 {name=Ci3 sig_type=std_logic lab=Vdd}
C {devices/gnd.sym} 3238 -2028 0 0 {name=Ci4 lab=GND}
C {devices/code_shown.sym} 2177 -2320 0 0 {name=S1 only_toplevel=false value=".tran 0.01n 100n
.save all"}
C {sky130_fd_pr/corner.sym} 1972 -2130 0 0 {name=CORNER only_toplevel=true corner=tt}
C {XOR2.sym} 5220 -1680 0 0 {name=x26}
C {XOR2.sym} 5510 -1670 0 0 {name=x27}
C {OR2.sym} 5690 -1440 0 0 {name=x28}
C {AND2.sym} 5490 -1480 0 0 {name=x29}
C {AND2.sym} 5490 -1390 0 0 {name=x30}
C {devices/opin.sym} 5650 -1670 0 0 {name=p6 lab=S4}
C {devices/lab_pin.sym} 5810 -1440 2 0 {name=p7 lab=Co5}
C {devices/ipin.sym} 5055 -1690 0 0 {name=p15 sig_type=std_logic lab=A0}
C {devices/ipin.sym} 4835 -1770 0 0 {name=p16 sig_type=std_logic lab=B0}
C {XOR2.sym} 6080 -1680 0 0 {name=x31}
C {XOR2.sym} 6370 -1670 0 0 {name=x32}
C {OR2.sym} 6550 -1440 0 0 {name=x33}
C {AND2.sym} 6350 -1480 0 0 {name=x34}
C {AND2.sym} 6350 -1390 0 0 {name=x35}
C {devices/opin.sym} 6510 -1670 0 0 {name=p22 lab=S5}
C {devices/ipin.sym} 5915 -1690 0 0 {name=p23 sig_type=std_logic lab=A1}
C {devices/ipin.sym} 5765 -1770 0 0 {name=p25 sig_type=std_logic lab=B1}
C {XOR2.sym} 6990 -1690 0 0 {name=x36}
C {XOR2.sym} 7280 -1680 0 0 {name=x37}
C {OR2.sym} 7460 -1450 0 0 {name=x38}
C {AND2.sym} 7260 -1490 0 0 {name=x39}
C {AND2.sym} 7260 -1400 0 0 {name=x40}
C {devices/opin.sym} 7420 -1680 0 0 {name=p30 lab=S6}
C {devices/ipin.sym} 6825 -1700 0 0 {name=p32 sig_type=std_logic lab=A2}
C {devices/ipin.sym} 6655 -1770 0 0 {name=p33 sig_type=std_logic lab=B2}
C {XOR2.sym} 7830 -1670 0 0 {name=x41}
C {XOR2.sym} 8120 -1660 0 0 {name=x42}
C {OR2.sym} 8300 -1430 0 0 {name=x43}
C {AND2.sym} 8100 -1470 0 0 {name=x44}
C {AND2.sym} 8100 -1380 0 0 {name=x45}
C {devices/opin.sym} 8260 -1660 0 0 {name=p35 lab=S7}
C {devices/ipin.sym} 7665 -1680 0 0 {name=p36 sig_type=std_logic lab=A3}
C {devices/ipin.sym} 7495 -1760 0 0 {name=p37 sig_type=std_logic lab=B3}
C {4_BIT_CLA_Carry_logic.sym} 6720 -790 0 0 {name=x46}
C {devices/lab_pin.sym} 6670 -1440 2 0 {name=p43 lab=Co6}
C {devices/lab_pin.sym} 7580 -1450 2 0 {name=p44 lab=Co7}
C {devices/lab_pin.sym} 8420 -1430 2 0 {name=p45 lab=Co8}
C {XOR2.sym} 4910 -1780 0 0 {name=x47}
C {XOR2.sym} 5860 -1780 0 0 {name=x48}
C {XOR2.sym} 6740 -1780 0 0 {name=x49}
C {XOR2.sym} 7580 -1770 0 0 {name=x50}
C {devices/opin.sym} 6930 -780 2 0 {name=p14 lab=Cout}
