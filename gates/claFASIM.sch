v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
B 2 810 -565 1610 -165 {flags=graph
y1=0
y2=2
ypos1=-0.47313425
ypos2=1.5268657

subdivy=1
unity=1
x1=-3.0826128e-09
x2=9.6917369e-08


xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
divx=10
divy=5
subdivx=1
digital=1


color="11 11 11 11 11"
node="a;a3,a2,a1,a0
b;b3,b2,b1,b0
c;c
c4;c4
s;c4,s3,s2,s1,s0"}
N 1820 -1450 1820 -1420 {
lab=#net1}
N 1820 -1420 1880 -1420 {
lab=#net1}
N 1820 -1400 1820 -1360 {
lab=g0}
N 1820 -1400 1880 -1400 {
lab=g0}
N 1630 -1630 1690 -1630 {
lab=C}
N 1630 -1630 1630 -1470 {
lab=C}
N 1630 -1470 1630 -1460 {
lab=C}
N 1630 -1460 1690 -1460 {
lab=C}
N 1600 -1440 1690 -1440 {
lab=p0}
N 1600 -1650 1600 -1440 {
lab=p0}
N 1600 -1650 1690 -1650 {
lab=p0}
N 1540 -1650 1600 -1650 {
lab=p0}
N 1770 -1450 1820 -1450 {
lab=#net1}
N 1770 -1360 1820 -1360 {
lab=g0}
N 2010 -1410 2050 -1410 {
lab=Co1}
N 1830 -1640 1890 -1640 {
lab=S0}
N 1295 -1660 1400 -1660 {
lab=A0}
N 1295 -1640 1400 -1640 {
lab=B0}
N 1355 -1370 1690 -1370 {
lab=A0}
N 1355 -1660 1355 -1370 {
lab=A0}
N 1325 -1350 1690 -1350 {
lab=B0}
N 1325 -1640 1325 -1350 {
lab=B0}
N 1300 -1460 1630 -1460 {
lab=C}
N 2680 -1450 2680 -1420 {
lab=#net2}
N 2680 -1420 2740 -1420 {
lab=#net2}
N 2680 -1400 2680 -1360 {
lab=g1}
N 2680 -1400 2740 -1400 {
lab=g1}
N 2490 -1630 2550 -1630 {
lab=C1}
N 2490 -1630 2490 -1470 {
lab=C1}
N 2490 -1470 2490 -1460 {
lab=C1}
N 2490 -1460 2550 -1460 {
lab=C1}
N 2460 -1440 2550 -1440 {
lab=p1}
N 2460 -1650 2460 -1440 {
lab=p1}
N 2460 -1650 2550 -1650 {
lab=p1}
N 2400 -1650 2460 -1650 {
lab=p1}
N 2630 -1450 2680 -1450 {
lab=#net2}
N 2630 -1360 2680 -1360 {
lab=g1}
N 2870 -1410 2910 -1410 {
lab=Co2}
N 2690 -1640 2750 -1640 {
lab=S1}
N 2155 -1660 2260 -1660 {
lab=A1}
N 2155 -1640 2260 -1640 {
lab=B1}
N 2215 -1370 2550 -1370 {
lab=A1}
N 2215 -1660 2215 -1370 {
lab=A1}
N 2185 -1350 2550 -1350 {
lab=B1}
N 2185 -1640 2185 -1350 {
lab=B1}
N 2160 -1460 2490 -1460 {
lab=C1}
N 3590 -1460 3590 -1430 {
lab=#net3}
N 3590 -1430 3650 -1430 {
lab=#net3}
N 3590 -1410 3590 -1370 {
lab=g2}
N 3590 -1410 3650 -1410 {
lab=g2}
N 3400 -1640 3460 -1640 {
lab=C2}
N 3400 -1640 3400 -1480 {
lab=C2}
N 3400 -1480 3400 -1470 {
lab=C2}
N 3400 -1470 3460 -1470 {
lab=C2}
N 3370 -1450 3460 -1450 {
lab=p2}
N 3370 -1660 3370 -1450 {
lab=p2}
N 3370 -1660 3460 -1660 {
lab=p2}
N 3310 -1660 3370 -1660 {
lab=p2}
N 3540 -1460 3590 -1460 {
lab=#net3}
N 3540 -1370 3590 -1370 {
lab=g2}
N 3780 -1420 3820 -1420 {
lab=Co3}
N 3600 -1650 3660 -1650 {
lab=S2}
N 3065 -1670 3170 -1670 {
lab=A2}
N 3065 -1650 3170 -1650 {
lab=B2}
N 3125 -1380 3460 -1380 {
lab=A2}
N 3125 -1670 3125 -1380 {
lab=A2}
N 3095 -1360 3460 -1360 {
lab=B2}
N 3095 -1650 3095 -1360 {
lab=B2}
N 3070 -1470 3400 -1470 {
lab=C2}
N 4430 -1440 4430 -1410 {
lab=#net4}
N 4430 -1410 4490 -1410 {
lab=#net4}
N 4430 -1390 4430 -1350 {
lab=g3}
N 4430 -1390 4490 -1390 {
lab=g3}
N 4240 -1620 4300 -1620 {
lab=C3}
N 4240 -1620 4240 -1460 {
lab=C3}
N 4240 -1460 4240 -1450 {
lab=C3}
N 4240 -1450 4300 -1450 {
lab=C3}
N 4210 -1430 4300 -1430 {
lab=p3}
N 4210 -1640 4210 -1430 {
lab=p3}
N 4210 -1640 4300 -1640 {
lab=p3}
N 4150 -1640 4210 -1640 {
lab=p3}
N 4380 -1440 4430 -1440 {
lab=#net4}
N 4380 -1350 4430 -1350 {
lab=g3}
N 4620 -1400 4660 -1400 {
lab=Co4}
N 4440 -1630 4500 -1630 {
lab=S3}
N 3905 -1650 4010 -1650 {
lab=A3}
N 3905 -1630 4010 -1630 {
lab=B3}
N 3965 -1360 4300 -1360 {
lab=A3}
N 3965 -1650 3965 -1360 {
lab=A3}
N 3935 -1340 4300 -1340 {
lab=B3}
N 3935 -1630 3935 -1340 {
lab=B3}
N 3910 -1450 4240 -1450 {
lab=C3}
N 1770 -1360 1770 -1000 {
lab=g0}
N 1770 -1000 3060 -1000 {
lab=g0}
N 3060 -1000 3060 -860 {
lab=g0}
N 1600 -1440 1600 -970 {
lab=p0}
N 1600 -970 2900 -970 {
lab=p0}
N 2900 -970 2900 -860 {
lab=p0}
N 2460 -1440 2460 -940 {
lab=p1}
N 2460 -940 2910 -940 {
lab=p1}
N 2910 -940 2920 -940 {
lab=p1}
N 2920 -940 2920 -860 {
lab=p1}
N 2660 -1360 2660 -1030 {
lab=g1}
N 2660 -1030 3030 -1030 {
lab=g1}
N 3030 -1030 3040 -1030 {
lab=g1}
N 3040 -1030 3040 -860 {
lab=g1}
N 2940 -1110 2940 -860 {
lab=p2}
N 2940 -1110 3370 -1110 {
lab=p2}
N 3370 -1450 3370 -1110 {
lab=p2}
N 3540 -1370 3540 -940 {
lab=g2}
N 3020 -940 3540 -940 {
lab=g2}
N 3020 -940 3020 -860 {
lab=g2}
N 3000 -960 3000 -860 {
lab=g3}
N 3000 -960 4430 -960 {
lab=g3}
N 4430 -1350 4430 -960 {
lab=g3}
N 4210 -1430 4210 -900 {
lab=p3}
N 2960 -900 4210 -900 {
lab=p3}
N 2960 -900 2960 -860 {
lab=p3}
N 1270 -790 2840 -790 {
lab=C}
N 1270 -1460 1270 -790 {
lab=C}
N 1270 -1460 1300 -1460 {
lab=C}
N 2160 -1460 2160 -670 {
lab=C1}
N 2160 -670 3150 -670 {
lab=C1}
N 3150 -810 3150 -670 {
lab=C1}
N 3110 -810 3150 -810 {
lab=C1}
N 3070 -1470 3070 -1150 {
lab=C2}
N 3070 -1150 3230 -1150 {
lab=C2}
N 3230 -1150 3230 -790 {
lab=C2}
N 3110 -790 3230 -790 {
lab=C2}
N 3110 -770 3920 -770 {
lab=C3}
N 3920 -1450 3920 -770 {
lab=C3}
N 3110 -750 3170 -750 {
lab=C4}
C {devices/code_shown.sym} 770 -685 0 0 {name=S1 only_toplevel=false value=".tran 0.01n 100n
.save all"}
C {sky130_fd_pr/corner.sym} 565 -495 0 0 {name=CORNER only_toplevel=true corner=tt}
C {devices/vsource.sym} 1890 -560 0 0 {name=VA4 value="pwl=0 1.8 50n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 1890 -590 0 0 {name=p38 sig_type=std_logic lab=A3}
C {devices/vsource.sym} 1890 -460 0 0 {name=VA5 value="pwl=0 1.8 50n 1.8 " savecurrent=false}
C {devices/lab_pin.sym} 1890 -490 0 0 {name=p39 sig_type=std_logic lab=A2}
C {devices/vsource.sym} 1890 -360 0 0 {name=VA6 value="pwl=0 1.8 50n 1.8 " savecurrent=false}
C {devices/lab_pin.sym} 1890 -390 0 0 {name=p40 sig_type=std_logic lab=A1}
C {devices/vsource.sym} 1890 -260 0 0 {name=VA0 value="pwl=0 1.8 50n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 1890 -290 0 0 {name=VA7 sig_type=std_logic lab=A0}
C {devices/vsource.sym} 1670 -570 0 0 {name=VB5 value="pwl=0 1.8 50n 1.8 " savecurrent=false}
C {devices/lab_pin.sym} 1670 -600 0 0 {name=VB4 sig_type=std_logic lab=B3}
C {devices/vsource.sym} 1670 -470 0 0 {name=VB6 value="pwl=0 1.8 50n 1.8 " savecurrent=false}
C {devices/lab_pin.sym} 1670 -500 0 0 {name=VB7 sig_type=std_logic lab=B2}
C {devices/vsource.sym} 1670 -370 0 0 {name=VB8 value="pwl=0 1.8 50n 1.8 " savecurrent=false}
C {devices/lab_pin.sym} 1670 -400 0 0 {name=VB9 sig_type=std_logic lab=B1}
C {devices/vsource.sym} 1670 -270 0 0 {name=VB0 value="pwl=0 1.8 50n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 1670 -300 0 0 {name=VB10 sig_type=std_logic lab=B0}
C {devices/gnd.sym} 1890 -230 0 0 {name=l7 lab=GND}
C {devices/gnd.sym} 1670 -240 0 0 {name=l8 lab=GND}
C {devices/gnd.sym} 1890 -330 0 0 {name=l15 lab=GND}
C {devices/gnd.sym} 1670 -340 0 0 {name=l16 lab=GND}
C {devices/gnd.sym} 1890 -430 0 0 {name=l17 lab=GND}
C {devices/gnd.sym} 1670 -440 0 0 {name=l18 lab=GND}
C {devices/gnd.sym} 1670 -540 0 0 {name=l19 lab=GND}
C {devices/gnd.sym} 1890 -530 0 0 {name=l20 lab=GND}
C {devices/vsource.sym} 1890 -140 0 0 {name=VCi value="pwl=0 0 50n 0 " savecurrent=false}
C {devices/lab_pin.sym} 1890 -170 0 0 {name=Ci1 sig_type=std_logic lab=C}
C {devices/gnd.sym} 1890 -110 0 0 {name=Ci2 lab=GND}
C {devices/vsource.sym} 1670 -150 0 0 {name=VDD1 value=1.8 savecurrent=false}
C {devices/lab_pin.sym} 1670 -180 0 0 {name=Ci3 sig_type=std_logic lab=Vdd}
C {devices/gnd.sym} 1670 -120 0 0 {name=Ci4 lab=GND}
C {XOR2.sym} 1460 -1650 0 0 {name=x22}
C {XOR2.sym} 1750 -1640 0 0 {name=x23}
C {OR2.sym} 1930 -1410 0 0 {name=x24}
C {AND2.sym} 1730 -1450 0 0 {name=x25}
C {AND2.sym} 1730 -1360 0 0 {name=x26}
C {devices/opin.sym} 1890 -1640 0 0 {name=p12 lab=S0}
C {devices/lab_pin.sym} 2050 -1410 2 0 {name=p13 lab=Co1}
C {devices/lab_pin.sym} 1295 -1660 0 0 {name=p32 sig_type=std_logic lab=A0}
C {devices/lab_pin.sym} 1295 -1640 0 0 {name=p33 sig_type=std_logic lab=B0}
C {devices/lab_pin.sym} 1300 -1460 0 0 {name=p34 sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 1595 -1650 0 0 {name=p35 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} 1805 -1360 0 0 {name=p36 sig_type=std_logic lab=g0}
C {XOR2.sym} 2320 -1650 0 0 {name=x27}
C {XOR2.sym} 2610 -1640 0 0 {name=x28}
C {OR2.sym} 2790 -1410 0 0 {name=x29}
C {AND2.sym} 2590 -1450 0 0 {name=x30}
C {AND2.sym} 2590 -1360 0 0 {name=x31}
C {devices/opin.sym} 2750 -1640 0 0 {name=p37 lab=S1}
C {devices/lab_pin.sym} 2155 -1660 0 0 {name=p41 sig_type=std_logic lab=A1}
C {devices/lab_pin.sym} 2155 -1640 0 0 {name=p42 sig_type=std_logic lab=B1}
C {devices/lab_pin.sym} 2160 -1460 0 0 {name=p43 sig_type=std_logic lab=C1}
C {devices/lab_pin.sym} 2455 -1650 0 0 {name=p44 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} 2665 -1360 0 0 {name=p45 sig_type=std_logic lab=g1}
C {XOR2.sym} 3230 -1660 0 0 {name=x32}
C {XOR2.sym} 3520 -1650 0 0 {name=x33}
C {OR2.sym} 3700 -1420 0 0 {name=x34}
C {AND2.sym} 3500 -1460 0 0 {name=x35}
C {AND2.sym} 3500 -1370 0 0 {name=x36}
C {devices/opin.sym} 3660 -1650 0 0 {name=p46 lab=S2}
C {devices/lab_pin.sym} 3065 -1670 0 0 {name=p47 sig_type=std_logic lab=A2}
C {devices/lab_pin.sym} 3065 -1650 0 0 {name=p48 sig_type=std_logic lab=B2}
C {devices/lab_pin.sym} 3070 -1470 0 0 {name=p49 sig_type=std_logic lab=C2}
C {devices/lab_pin.sym} 3365 -1660 0 0 {name=p50 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} 3575 -1370 0 0 {name=p51 sig_type=std_logic lab=g2}
C {XOR2.sym} 4070 -1640 0 0 {name=x37}
C {XOR2.sym} 4360 -1630 0 0 {name=x38}
C {OR2.sym} 4540 -1400 0 0 {name=x39}
C {AND2.sym} 4340 -1440 0 0 {name=x40}
C {AND2.sym} 4340 -1350 0 0 {name=x41}
C {devices/opin.sym} 4500 -1630 0 0 {name=p52 lab=S3}
C {devices/lab_pin.sym} 3905 -1650 0 0 {name=p53 sig_type=std_logic lab=A3}
C {devices/lab_pin.sym} 3905 -1630 0 0 {name=p54 sig_type=std_logic lab=B3}
C {devices/lab_pin.sym} 3910 -1450 0 0 {name=p55 sig_type=std_logic lab=C3}
C {devices/lab_pin.sym} 4205 -1640 0 0 {name=p56 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} 4415 -1350 0 0 {name=p57 sig_type=std_logic lab=g3}
C {4_BIT_CLA_Carry_logic.sym} 2960 -760 0 0 {name=x42}
C {devices/opin.sym} 3170 -750 0 0 {name=p58 lab=C4}
C {devices/lab_pin.sym} 2910 -1410 2 0 {name=p59 lab=Co2}
C {devices/lab_pin.sym} 3820 -1420 2 0 {name=p60 lab=Co3}
C {devices/lab_pin.sym} 4660 -1400 2 0 {name=p61 lab=Co4}
