v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 4450 -6050 4450 -3740 {
lab=S0}
N 4450 -6010 4500 -6010 {
lab=S0}
N 4400 -5990 4500 -5990 {
lab=S1}
N 4450 -5860 4500 -5860 {
lab=S0}
N 4400 -5840 4500 -5840 {
lab=S1}
N 4450 -5710 4500 -5710 {
lab=S0}
N 4400 -5690 4500 -5690 {
lab=S1}
N 4450 -5560 4500 -5560 {
lab=S0}
N 4400 -5540 4500 -5540 {
lab=S1}
N 4450 -5410 4500 -5410 {
lab=S0}
N 4400 -5390 4500 -5390 {
lab=S1}
N 4450 -5260 4500 -5260 {
lab=S0}
N 4400 -5240 4500 -5240 {
lab=S1}
N 4450 -5110 4500 -5110 {
lab=S0}
N 4400 -5090 4500 -5090 {
lab=S1}
N 4450 -4960 4500 -4960 {
lab=S0}
N 4400 -4940 4500 -4940 {
lab=S1}
N 4450 -4810 4500 -4810 {
lab=S0}
N 4400 -4790 4500 -4790 {
lab=S1}
N 4450 -4660 4500 -4660 {
lab=S0}
N 4400 -4640 4500 -4640 {
lab=S1}
N 4450 -4510 4500 -4510 {
lab=S0}
N 4400 -4490 4500 -4490 {
lab=S1}
N 4450 -4360 4500 -4360 {
lab=S0}
N 4400 -4340 4500 -4340 {
lab=S1}
N 4450 -4210 4500 -4210 {
lab=S0}
N 4400 -4190 4500 -4190 {
lab=S1}
N 4450 -4060 4500 -4060 {
lab=S0}
N 4400 -4040 4500 -4040 {
lab=S1}
N 4450 -3910 4500 -3910 {
lab=S0}
N 4400 -3890 4500 -3890 {
lab=S1}
N 4450 -3810 4450 -1500 {
lab=S0}
N 4400 -3800 4400 -1490 {
lab=S1}
N 4450 -3750 4500 -3750 {
lab=S0}
N 4400 -3730 4500 -3730 {
lab=S1}
N 4450 -3600 4500 -3600 {
lab=S0}
N 4400 -3580 4500 -3580 {
lab=S1}
N 4450 -3450 4500 -3450 {
lab=S0}
N 4400 -3430 4500 -3430 {
lab=S1}
N 4450 -3300 4500 -3300 {
lab=S0}
N 4400 -3280 4500 -3280 {
lab=S1}
N 4450 -3150 4500 -3150 {
lab=S0}
N 4400 -3130 4500 -3130 {
lab=S1}
N 4450 -3000 4500 -3000 {
lab=S0}
N 4400 -2980 4500 -2980 {
lab=S1}
N 4450 -2850 4500 -2850 {
lab=S0}
N 4400 -2830 4500 -2830 {
lab=S1}
N 4450 -2700 4500 -2700 {
lab=S0}
N 4400 -2680 4500 -2680 {
lab=S1}
N 4450 -2550 4500 -2550 {
lab=S0}
N 4400 -2530 4500 -2530 {
lab=S1}
N 4450 -2400 4500 -2400 {
lab=S0}
N 4400 -2380 4500 -2380 {
lab=S1}
N 4450 -2250 4500 -2250 {
lab=S0}
N 4400 -2230 4500 -2230 {
lab=S1}
N 4450 -2100 4500 -2100 {
lab=S0}
N 4400 -2080 4500 -2080 {
lab=S1}
N 4450 -1950 4500 -1950 {
lab=S0}
N 4400 -1930 4500 -1930 {
lab=S1}
N 4450 -1800 4500 -1800 {
lab=S0}
N 4400 -1780 4500 -1780 {
lab=S1}
N 4450 -1650 4500 -1650 {
lab=S0}
N 4400 -1630 4500 -1630 {
lab=S1}
N 4450 -1500 4500 -1500 {
lab=S0}
N 4400 -1480 4500 -1480 {
lab=S1}
N 4450 -1350 4500 -1350 {
lab=S0}
N 4400 -1330 4500 -1330 {
lab=S1}
N 4400 -1490 4400 -1330 {
lab=S1}
N 4630 -5990 4690 -5990 {
lab=O[0]}
N 4630 -5840 4690 -5840 {
lab=O[1]}
N 4630 -5690 4690 -5690 {
lab=O[2]}
N 4630 -5540 4690 -5540 {
lab=O[3]}
N 4630 -5390 4690 -5390 {
lab=O[4]}
N 4630 -5240 4690 -5240 {
lab=O[5]}
N 4630 -5090 4690 -5090 {
lab=O[6]}
N 4630 -4940 4690 -4940 {
lab=O[7]}
N 4630 -4790 4690 -4790 {
lab=O[8]}
N 4630 -4640 4690 -4640 {
lab=O[9]}
N 4630 -4490 4690 -4490 {
lab=O[10]}
N 4630 -4340 4690 -4340 {
lab=O[11]}
N 4630 -4190 4690 -4190 {
lab=O[12]}
N 4630 -4040 4690 -4040 {
lab=O[13]}
N 4630 -3890 4690 -3890 {
lab=O[14]}
N 4630 -3730 4690 -3730 {
lab=O[15]}
N 4630 -3580 4690 -3580 {
lab=O[16]}
N 4630 -3430 4690 -3430 {
lab=O[17]}
N 4630 -3280 4690 -3280 {
lab=O[18]}
N 4630 -3130 4690 -3130 {
lab=O[19]}
N 4630 -2980 4690 -2980 {
lab=O[20]}
N 4630 -2830 4690 -2830 {
lab=O[21]}
N 4630 -2680 4690 -2680 {
lab=O[22]}
N 4630 -2530 4690 -2530 {
lab=O[23]}
N 4630 -2380 4690 -2380 {
lab=O[24]}
N 4630 -2230 4690 -2230 {
lab=O[25]}
N 4630 -2080 4690 -2080 {
lab=O[26]}
N 4630 -1930 4690 -1930 {
lab=O[27]}
N 4630 -1780 4690 -1780 {
lab=O[28]}
N 4630 -1630 4690 -1630 {
lab=O[29]}
N 4630 -1480 4690 -1480 {
lab=O[30]}
N 4630 -1330 4690 -1330 {
lab=O[31]}
N 4200 -5960 4500 -5960 {
lab=AND[0]}
N 4200 -5810 4500 -5810 {
lab=AND[1]}
N 4200 -5660 4500 -5660 {
lab=AND[2]}
N 4200 -5510 4500 -5510 {
lab=AND[3]}
N 4200 -5360 4500 -5360 {
lab=AND[4]}
N 4200 -5210 4500 -5210 {
lab=AND[5]}
N 4200 -5060 4500 -5060 {
lab=AND[6]}
N 4200 -4910 4500 -4910 {
lab=AND[7]}
N 4200 -4760 4500 -4760 {
lab=AND[8]}
N 4200 -4610 4500 -4610 {
lab=AND[9]}
N 4200 -4460 4500 -4460 {
lab=AND[10]}
N 4200 -4310 4500 -4310 {
lab=AND[11]}
N 4200 -4160 4500 -4160 {
lab=AND[12]}
N 4200 -4010 4500 -4010 {
lab=AND[13]}
N 4200 -3860 4500 -3860 {
lab=AND[14]}
N 4200 -3700 4500 -3700 {
lab=AND[15]}
N 4200 -3550 4500 -3550 {
lab=AND[16]}
N 4200 -3410 4500 -3410 {
lab=AND[17]}
N 4200 -3250 4500 -3250 {
lab=AND[18]}
N 4200 -3100 4500 -3100 {
lab=AND[19]}
N 4200 -2950 4500 -2950 {
lab=AND[20]}
N 4200 -2800 4500 -2800 {
lab=AND[21]}
N 4200 -2650 4500 -2650 {
lab=AND[22]}
N 4200 -2500 4500 -2500 {
lab=AND[23]}
N 4200 -2350 4500 -2350 {
lab=AND[24]}
N 4200 -2200 4500 -2200 {
lab=AND[25]}
N 4200 -2050 4500 -2050 {
lab=AND[26]}
N 4200 -1900 4500 -1900 {
lab=AND[27]}
N 4200 -1750 4500 -1750 {
lab=AND[28]}
N 4200 -1600 4500 -1600 {
lab=AND[29]}
N 4200 -1450 4500 -1450 {
lab=AND[30]}
N 4200 -1300 4500 -1300 {
lab=AND[31]}
N 4200 -5940 4500 -5940 {
lab=OR[0]}
N 4200 -5790 4500 -5790 {
lab=OR[1]}
N 4200 -5640 4500 -5640 {
lab=OR[2]}
N 4200 -5490 4500 -5490 {
lab=OR[3]}
N 4200 -5340 4500 -5340 {
lab=OR[4]}
N 4200 -5190 4500 -5190 {
lab=OR[5]}
N 4200 -5040 4500 -5040 {
lab=OR[6]}
N 4200 -4890 4500 -4890 {
lab=OR[7]}
N 4200 -4740 4500 -4740 {
lab=OR[8]}
N 4200 -4590 4500 -4590 {
lab=OR[9]}
N 4200 -4440 4500 -4440 {
lab=OR[10]}
N 4200 -4290 4500 -4290 {
lab=OR[11]}
N 4200 -4140 4500 -4140 {
lab=OR[12]}
N 4200 -3990 4500 -3990 {
lab=OR[13]}
N 4200 -3840 4500 -3840 {
lab=OR[14]}
N 4200 -3680 4500 -3680 {
lab=AND[15]}
N 4200 -3530 4500 -3530 {
lab=OR[16]}
N 4200 -3390 4500 -3390 {
lab=OR[17]}
N 4200 -3230 4500 -3230 {
lab=OR[18]}
N 4200 -3080 4500 -3080 {
lab=OR[19]}
N 4200 -2930 4500 -2930 {
lab=OR[20]}
N 4200 -2780 4500 -2780 {
lab=OR[21]}
N 4200 -2630 4500 -2630 {
lab=OR[22]}
N 4200 -2480 4500 -2480 {
lab=OR[23]}
N 4200 -2330 4500 -2330 {
lab=OR[24]}
N 4200 -2180 4500 -2180 {
lab=OR[25]}
N 4200 -2030 4500 -2030 {
lab=OR[26]}
N 4200 -1880 4500 -1880 {
lab=OR[27]}
N 4200 -1730 4500 -1730 {
lab=OR[28]}
N 4200 -1580 4500 -1580 {
lab=OR[29]}
N 4200 -1430 4500 -1430 {
lab=OR[30]}
N 4200 -1280 4500 -1280 {
lab=OR[31]}
N 4200 -5920 4500 -5920 {
lab=XOR[0]}
N 4200 -5770 4500 -5770 {
lab=XOR[1]}
N 4200 -5620 4500 -5620 {
lab=XOR[2]}
N 4200 -5470 4500 -5470 {
lab=XOR[3]}
N 4200 -5320 4500 -5320 {
lab=XOR[4]}
N 4200 -5170 4500 -5170 {
lab=XOR[5]}
N 4200 -5020 4500 -5020 {
lab=XOR[6]}
N 4200 -4870 4500 -4870 {
lab=XOR[7]}
N 4200 -4720 4500 -4720 {
lab=XOR[8]}
N 4200 -4570 4500 -4570 {
lab=XOR[9]}
N 4200 -4420 4500 -4420 {
lab=XOR[10]}
N 4200 -4270 4500 -4270 {
lab=XOR[11]}
N 4200 -4120 4500 -4120 {
lab=XOR[12]}
N 4200 -3970 4500 -3970 {
lab=XOR[13]}
N 4200 -3820 4500 -3820 {
lab=XOR[14]}
N 4200 -3660 4500 -3660 {
lab=AND[15]}
N 4200 -3510 4500 -3510 {
lab=XOR[16]}
N 4200 -3370 4500 -3370 {
lab=XOR[17]}
N 4200 -3210 4500 -3210 {
lab=XOR[18]}
N 4200 -3060 4500 -3060 {
lab=XOR[19]}
N 4200 -2910 4500 -2910 {
lab=XOR[20]}
N 4200 -2760 4500 -2760 {
lab=XOR[21]}
N 4200 -2610 4500 -2610 {
lab=XOR[22]}
N 4200 -2460 4500 -2460 {
lab=XOR[23]}
N 4200 -2310 4500 -2310 {
lab=XOR[24]}
N 4200 -2160 4500 -2160 {
lab=XOR[25]}
N 4200 -2010 4500 -2010 {
lab=XOR[26]}
N 4200 -1860 4500 -1860 {
lab=XOR[27]}
N 4200 -1710 4500 -1710 {
lab=XOR[28]}
N 4200 -1560 4500 -1560 {
lab=XOR[29]}
N 4200 -1410 4500 -1410 {
lab=XOR[30]}
N 4200 -1260 4500 -1260 {
lab=XOR[31]}
N 3900 -2950 3900 -1680 {
bus=true lab=XOR[31:0]}
N 3630 -2940 3630 -2740 {
lab=XOR[0]}
N 3630 -2940 3730 -2940 {
lab=XOR[0]}
N 3630 -2720 3640 -2720 {
lab=XOR[1]}
N 3640 -2900 3640 -2720 {
lab=XOR[1]}
N 3640 -2900 3730 -2900 {
lab=XOR[1]}
N 3650 -2860 3730 -2860 {
lab=XOR[2]}
N 3650 -2860 3650 -2700 {
lab=XOR[2]}
N 3630 -2700 3650 -2700 {
lab=XOR[2]}
N 3660 -2820 3730 -2820 {
lab=XOR[3]}
N 3660 -2820 3660 -2680 {
lab=XOR[3]}
N 3630 -2680 3660 -2680 {
lab=XOR[3]}
N 3670 -2780 3730 -2780 {
lab=XOR[4]}
N 3670 -2780 3670 -2660 {
lab=XOR[4]}
N 3630 -2660 3670 -2660 {
lab=XOR[4]}
N 3680 -2740 3730 -2740 {
lab=XOR[5]}
N 3680 -2740 3680 -2640 {
lab=XOR[5]}
N 3630 -2640 3680 -2640 {
lab=XOR[5]}
N 3690 -2700 3730 -2700 {
lab=XOR[6]}
N 3690 -2700 3690 -2620 {
lab=XOR[6]}
N 3630 -2620 3690 -2620 {
lab=XOR[6]}
N 3730 -2940 3890 -2940 {
lab=XOR[0]}
N 3730 -2900 3890 -2900 {
lab=XOR[1]}
N 3730 -2860 3890 -2860 {
lab=XOR[2]}
N 3730 -2820 3890 -2820 {
lab=XOR[3]}
N 3730 -2780 3890 -2780 {
lab=XOR[4]}
N 3730 -2740 3890 -2740 {
lab=XOR[5]}
N 3730 -2700 3890 -2700 {
lab=XOR[6]}
N 3700 -2660 3890 -2660 {
lab=XOR[7]}
N 3700 -2660 3700 -2600 {
lab=XOR[7]}
N 3630 -2600 3700 -2600 {
lab=XOR[7]}
N 3710 -2620 3890 -2620 {
lab=XOR[8]}
N 3710 -2620 3710 -2580 {
lab=XOR[8]}
N 3630 -2580 3710 -2580 {
lab=XOR[8]}
N 3720 -2580 3890 -2580 {
lab=XOR[9]}
N 3720 -2580 3720 -2560 {
lab=XOR[9]}
N 3630 -2560 3720 -2560 {
lab=XOR[9]}
N 3630 -2540 3890 -2540 {
lab=XOR[10]}
N 3630 -1690 3890 -1690 {
lab=XOR[31]}
N 3630 -2120 3630 -1690 {
lab=XOR[31]}
N 3640 -1730 3890 -1730 {
lab=XOR[30]}
N 3640 -2140 3640 -1730 {
lab=XOR[30]}
N 3630 -2140 3640 -2140 {
lab=XOR[30]}
N 3650 -1780 3890 -1780 {
lab=XOR[29]}
N 3650 -2160 3650 -1780 {
lab=XOR[29]}
N 3630 -2160 3650 -2160 {
lab=XOR[29]}
N 3660 -1820 3890 -1820 {
lab=XOR[28]}
N 3660 -2180 3660 -1820 {
lab=XOR[28]}
N 3630 -2180 3660 -2180 {
lab=XOR[28]}
N 3670 -1860 3890 -1860 {
lab=XOR[27]}
N 3670 -2200 3670 -1860 {
lab=XOR[27]}
N 3630 -2200 3670 -2200 {
lab=XOR[27]}
N 3680 -1900 3890 -1900 {
lab=XOR[26]}
N 3680 -2220 3680 -1900 {
lab=XOR[26]}
N 3630 -2220 3680 -2220 {
lab=XOR[26]}
N 3690 -1940 3890 -1940 {
lab=XOR[25]}
N 3690 -2240 3690 -1940 {
lab=XOR[25]}
N 3630 -2240 3690 -2240 {
lab=XOR[25]}
N 3700 -1980 3890 -1980 {
lab=XOR[24]}
N 3700 -2260 3700 -1980 {
lab=XOR[24]}
N 3630 -2260 3700 -2260 {
lab=XOR[24]}
N 3710 -2020 3890 -2020 {
lab=XOR[23]}
N 3710 -2280 3710 -2020 {
lab=XOR[23]}
N 3630 -2280 3710 -2280 {
lab=XOR[23]}
N 3720 -2060 3890 -2060 {
lab=XOR[22]}
N 3720 -2300 3720 -2060 {
lab=XOR[22]}
N 3630 -2300 3720 -2300 {
lab=XOR[22]}
N 3730 -2100 3890 -2100 {
lab=XOR[21]}
N 3730 -2320 3730 -2100 {
lab=XOR[21]}
N 3630 -2320 3730 -2320 {
lab=XOR[21]}
N 3740 -2140 3890 -2140 {
lab=XOR[20]}
N 3740 -2340 3740 -2140 {
lab=XOR[20]}
N 3630 -2340 3740 -2340 {
lab=XOR[20]}
N 3750 -2180 3890 -2180 {
lab=XOR[19]}
N 3750 -2360 3750 -2180 {
lab=XOR[19]}
N 3630 -2360 3750 -2360 {
lab=XOR[19]}
N 3760 -2220 3890 -2220 {
lab=XOR[18]}
N 3760 -2380 3760 -2220 {
lab=XOR[18]}
N 3630 -2380 3760 -2380 {
lab=XOR[18]}
N 3770 -2260 3890 -2260 {
lab=XOR[17]}
N 3770 -2390 3770 -2260 {
lab=XOR[17]}
N 3770 -2400 3770 -2390 {
lab=XOR[17]}
N 3630 -2400 3770 -2400 {
lab=XOR[17]}
N 3780 -2300 3890 -2300 {
lab=XOR[16]}
N 3780 -2420 3780 -2300 {
lab=XOR[16]}
N 3630 -2420 3780 -2420 {
lab=XOR[16]}
N 3790 -2340 3890 -2340 {
lab=XOR[15]}
N 3790 -2440 3790 -2340 {
lab=XOR[15]}
N 3630 -2440 3790 -2440 {
lab=XOR[15]}
N 3800 -2380 3890 -2380 {
lab=XOR[14]}
N 3800 -2460 3800 -2380 {
lab=XOR[14]}
N 3630 -2460 3800 -2460 {
lab=XOR[14]}
N 3810 -2420 3890 -2420 {
lab=XOR[13]}
N 3810 -2480 3810 -2420 {
lab=XOR[13]}
N 3630 -2480 3810 -2480 {
lab=XOR[13]}
N 3820 -2460 3890 -2460 {
lab=XOR[12]}
N 3820 -2500 3820 -2460 {
lab=XOR[12]}
N 3630 -2500 3820 -2500 {
lab=XOR[12]}
N 3630 -2520 3830 -2520 {
lab=XOR[11]}
N 3830 -2520 3830 -2500 {
lab=XOR[11]}
N 3830 -2500 3890 -2500 {
lab=XOR[11]}
N 3900 -4400 3900 -3130 {
bus=true lab=OR[31:0]}
N 3630 -4390 3630 -4190 {
lab=OR[0]}
N 3630 -4390 3730 -4390 {
lab=OR[0]}
N 3630 -4170 3640 -4170 {
lab=OR[1]}
N 3640 -4350 3640 -4170 {
lab=OR[1]}
N 3640 -4350 3730 -4350 {
lab=OR[1]}
N 3650 -4310 3730 -4310 {
lab=OR[2]}
N 3650 -4310 3650 -4150 {
lab=OR[2]}
N 3630 -4150 3650 -4150 {
lab=OR[2]}
N 3660 -4270 3730 -4270 {
lab=OR[3]}
N 3660 -4270 3660 -4130 {
lab=OR[3]}
N 3630 -4130 3660 -4130 {
lab=OR[3]}
N 3670 -4230 3730 -4230 {
lab=OR[4]}
N 3670 -4230 3670 -4110 {
lab=OR[4]}
N 3630 -4110 3670 -4110 {
lab=OR[4]}
N 3680 -4190 3730 -4190 {
lab=OR[5]}
N 3680 -4190 3680 -4090 {
lab=OR[5]}
N 3630 -4090 3680 -4090 {
lab=OR[5]}
N 3690 -4150 3730 -4150 {
lab=OR[6]}
N 3690 -4150 3690 -4070 {
lab=OR[6]}
N 3630 -4070 3690 -4070 {
lab=OR[6]}
N 3730 -4390 3890 -4390 {
lab=OR[0]}
N 3730 -4350 3890 -4350 {
lab=OR[1]}
N 3730 -4310 3890 -4310 {
lab=OR[2]}
N 3730 -4270 3890 -4270 {
lab=OR[3]}
N 3730 -4230 3890 -4230 {
lab=OR[4]}
N 3730 -4190 3890 -4190 {
lab=OR[5]}
N 3730 -4150 3890 -4150 {
lab=OR[6]}
N 3700 -4110 3890 -4110 {
lab=OR[7]}
N 3700 -4110 3700 -4050 {
lab=OR[7]}
N 3630 -4050 3700 -4050 {
lab=OR[7]}
N 3710 -4070 3890 -4070 {
lab=OR[8]}
N 3710 -4070 3710 -4030 {
lab=OR[8]}
N 3630 -4030 3710 -4030 {
lab=OR[8]}
N 3720 -4030 3890 -4030 {
lab=OR[9]}
N 3720 -4030 3720 -4010 {
lab=OR[9]}
N 3630 -4010 3720 -4010 {
lab=OR[9]}
N 3630 -3990 3890 -3990 {
lab=OR[10]}
N 3630 -3140 3890 -3140 {
lab=OR[31]}
N 3630 -3570 3630 -3140 {
lab=OR[31]}
N 3640 -3180 3890 -3180 {
lab=OR[30]}
N 3640 -3590 3640 -3180 {
lab=OR[30]}
N 3630 -3590 3640 -3590 {
lab=OR[30]}
N 3650 -3230 3890 -3230 {
lab=OR[29]}
N 3650 -3610 3650 -3230 {
lab=OR[29]}
N 3630 -3610 3650 -3610 {
lab=OR[29]}
N 3660 -3270 3890 -3270 {
lab=OR[28]}
N 3660 -3630 3660 -3270 {
lab=OR[28]}
N 3630 -3630 3660 -3630 {
lab=OR[28]}
N 3670 -3310 3890 -3310 {
lab=OR[27]}
N 3670 -3650 3670 -3310 {
lab=OR[27]}
N 3630 -3650 3670 -3650 {
lab=OR[27]}
N 3680 -3350 3890 -3350 {
lab=OR[26]}
N 3680 -3670 3680 -3350 {
lab=OR[26]}
N 3630 -3670 3680 -3670 {
lab=OR[26]}
N 3690 -3390 3890 -3390 {
lab=OR[25]}
N 3690 -3690 3690 -3390 {
lab=OR[25]}
N 3630 -3690 3690 -3690 {
lab=OR[25]}
N 3700 -3430 3890 -3430 {
lab=OR[24]}
N 3700 -3710 3700 -3430 {
lab=OR[24]}
N 3630 -3710 3700 -3710 {
lab=OR[24]}
N 3710 -3470 3890 -3470 {
lab=OR[23]}
N 3710 -3730 3710 -3470 {
lab=OR[23]}
N 3630 -3730 3710 -3730 {
lab=OR[23]}
N 3720 -3510 3890 -3510 {
lab=OR[22]}
N 3720 -3750 3720 -3510 {
lab=OR[22]}
N 3630 -3750 3720 -3750 {
lab=OR[22]}
N 3730 -3550 3890 -3550 {
lab=OR[21]}
N 3730 -3770 3730 -3550 {
lab=OR[21]}
N 3630 -3770 3730 -3770 {
lab=OR[21]}
N 3740 -3590 3890 -3590 {
lab=OR[20]}
N 3740 -3790 3740 -3590 {
lab=OR[20]}
N 3630 -3790 3740 -3790 {
lab=OR[20]}
N 3750 -3630 3890 -3630 {
lab=OR[19]}
N 3750 -3810 3750 -3630 {
lab=OR[19]}
N 3630 -3810 3750 -3810 {
lab=OR[19]}
N 3760 -3670 3890 -3670 {
lab=OR[18]}
N 3760 -3830 3760 -3670 {
lab=OR[18]}
N 3630 -3830 3760 -3830 {
lab=OR[18]}
N 3770 -3710 3890 -3710 {
lab=OR[17]}
N 3770 -3840 3770 -3710 {
lab=OR[17]}
N 3770 -3850 3770 -3840 {
lab=OR[17]}
N 3630 -3850 3770 -3850 {
lab=OR[17]}
N 3780 -3750 3890 -3750 {
lab=OR[16]}
N 3780 -3870 3780 -3750 {
lab=OR[16]}
N 3630 -3870 3780 -3870 {
lab=OR[16]}
N 3790 -3790 3890 -3790 {
lab=OR[15]}
N 3790 -3890 3790 -3790 {
lab=OR[15]}
N 3630 -3890 3790 -3890 {
lab=OR[15]}
N 3800 -3830 3890 -3830 {
lab=OR[14]}
N 3800 -3910 3800 -3830 {
lab=OR[14]}
N 3630 -3910 3800 -3910 {
lab=OR[14]}
N 3810 -3870 3890 -3870 {
lab=OR[13]}
N 3810 -3930 3810 -3870 {
lab=OR[13]}
N 3630 -3930 3810 -3930 {
lab=OR[13]}
N 3820 -3910 3890 -3910 {
lab=OR[12]}
N 3820 -3950 3820 -3910 {
lab=OR[12]}
N 3630 -3950 3820 -3950 {
lab=OR[12]}
N 3630 -3970 3830 -3970 {
lab=OR[11]}
N 3830 -3970 3830 -3950 {
lab=OR[11]}
N 3830 -3950 3890 -3950 {
lab=OR[11]}
N 3890 -5920 3890 -4650 {
bus=true lab=AND[31:0]}
N 3620 -5910 3620 -5710 {
lab=AND[0]}
N 3620 -5910 3720 -5910 {
lab=AND[0]}
N 3620 -5690 3630 -5690 {
lab=AND[1]}
N 3630 -5870 3630 -5690 {
lab=AND[1]}
N 3630 -5870 3720 -5870 {
lab=AND[1]}
N 3640 -5830 3720 -5830 {
lab=AND[2]}
N 3640 -5830 3640 -5670 {
lab=AND[2]}
N 3620 -5670 3640 -5670 {
lab=AND[2]}
N 3650 -5790 3720 -5790 {
lab=AND[3]}
N 3650 -5790 3650 -5650 {
lab=AND[3]}
N 3620 -5650 3650 -5650 {
lab=AND[3]}
N 3660 -5750 3720 -5750 {
lab=AND[4]}
N 3660 -5750 3660 -5630 {
lab=AND[4]}
N 3620 -5630 3660 -5630 {
lab=AND[4]}
N 3670 -5710 3720 -5710 {
lab=AND[5]}
N 3670 -5710 3670 -5610 {
lab=AND[5]}
N 3620 -5610 3670 -5610 {
lab=AND[5]}
N 3680 -5670 3720 -5670 {
lab=AND[6]}
N 3680 -5670 3680 -5590 {
lab=AND[6]}
N 3620 -5590 3680 -5590 {
lab=AND[6]}
N 3720 -5910 3880 -5910 {
lab=AND[0]}
N 3720 -5870 3880 -5870 {
lab=AND[1]}
N 3720 -5830 3880 -5830 {
lab=AND[2]}
N 3720 -5790 3880 -5790 {
lab=AND[3]}
N 3720 -5750 3880 -5750 {
lab=AND[4]}
N 3720 -5710 3880 -5710 {
lab=AND[5]}
N 3720 -5670 3880 -5670 {
lab=AND[6]}
N 3690 -5630 3880 -5630 {
lab=AND[7]}
N 3690 -5630 3690 -5570 {
lab=AND[7]}
N 3620 -5570 3690 -5570 {
lab=AND[7]}
N 3700 -5590 3880 -5590 {
lab=AND[8]}
N 3700 -5590 3700 -5550 {
lab=AND[8]}
N 3620 -5550 3700 -5550 {
lab=AND[8]}
N 3710 -5550 3880 -5550 {
lab=AND[9]}
N 3710 -5550 3710 -5530 {
lab=AND[9]}
N 3620 -5530 3710 -5530 {
lab=AND[9]}
N 3620 -5510 3880 -5510 {
lab=AND[10]}
N 3620 -4660 3880 -4660 {
lab=AND[31]}
N 3620 -5090 3620 -4660 {
lab=AND[31]}
N 3630 -4700 3880 -4700 {
lab=AND[30]}
N 3630 -5110 3630 -4700 {
lab=AND[30]}
N 3620 -5110 3630 -5110 {
lab=AND[30]}
N 3640 -4750 3880 -4750 {
lab=AND[29]}
N 3640 -5130 3640 -4750 {
lab=AND[29]}
N 3620 -5130 3640 -5130 {
lab=AND[29]}
N 3650 -4790 3880 -4790 {
lab=AND[28]}
N 3650 -5150 3650 -4790 {
lab=AND[28]}
N 3620 -5150 3650 -5150 {
lab=AND[28]}
N 3660 -4830 3880 -4830 {
lab=AND[27]}
N 3660 -5170 3660 -4830 {
lab=AND[27]}
N 3620 -5170 3660 -5170 {
lab=AND[27]}
N 3670 -4870 3880 -4870 {
lab=AND[26]}
N 3670 -5190 3670 -4870 {
lab=AND[26]}
N 3620 -5190 3670 -5190 {
lab=AND[26]}
N 3680 -4910 3880 -4910 {
lab=AND[25]}
N 3680 -5210 3680 -4910 {
lab=AND[25]}
N 3620 -5210 3680 -5210 {
lab=AND[25]}
N 3690 -4950 3880 -4950 {
lab=AND[24]}
N 3690 -5230 3690 -4950 {
lab=AND[24]}
N 3620 -5230 3690 -5230 {
lab=AND[24]}
N 3700 -4990 3880 -4990 {
lab=AND[23]}
N 3700 -5250 3700 -4990 {
lab=AND[23]}
N 3620 -5250 3700 -5250 {
lab=AND[23]}
N 3710 -5030 3880 -5030 {
lab=AND[22]}
N 3710 -5270 3710 -5030 {
lab=AND[22]}
N 3620 -5270 3710 -5270 {
lab=AND[22]}
N 3720 -5070 3880 -5070 {
lab=AND[21]}
N 3720 -5290 3720 -5070 {
lab=AND[21]}
N 3620 -5290 3720 -5290 {
lab=AND[21]}
N 3730 -5110 3880 -5110 {
lab=AND[20]}
N 3730 -5310 3730 -5110 {
lab=AND[20]}
N 3620 -5310 3730 -5310 {
lab=AND[20]}
N 3740 -5150 3880 -5150 {
lab=AND[19]}
N 3740 -5330 3740 -5150 {
lab=AND[19]}
N 3620 -5330 3740 -5330 {
lab=AND[19]}
N 3750 -5190 3880 -5190 {
lab=AND[18]}
N 3750 -5350 3750 -5190 {
lab=AND[18]}
N 3620 -5350 3750 -5350 {
lab=AND[18]}
N 3760 -5230 3880 -5230 {
lab=AND[17]}
N 3760 -5360 3760 -5230 {
lab=AND[17]}
N 3760 -5370 3760 -5360 {
lab=AND[17]}
N 3620 -5370 3760 -5370 {
lab=AND[17]}
N 3770 -5270 3880 -5270 {
lab=AND[16]}
N 3770 -5390 3770 -5270 {
lab=AND[16]}
N 3620 -5390 3770 -5390 {
lab=AND[16]}
N 3780 -5310 3880 -5310 {
lab=AND[15]}
N 3780 -5410 3780 -5310 {
lab=AND[15]}
N 3620 -5410 3780 -5410 {
lab=AND[15]}
N 3790 -5350 3880 -5350 {
lab=AND[14]}
N 3790 -5430 3790 -5350 {
lab=AND[14]}
N 3620 -5430 3790 -5430 {
lab=AND[14]}
N 3800 -5390 3880 -5390 {
lab=AND[13]}
N 3800 -5450 3800 -5390 {
lab=AND[13]}
N 3620 -5450 3800 -5450 {
lab=AND[13]}
N 3810 -5430 3880 -5430 {
lab=AND[12]}
N 3810 -5470 3810 -5430 {
lab=AND[12]}
N 3620 -5470 3810 -5470 {
lab=AND[12]}
N 3620 -5490 3820 -5490 {
lab=AND[11]}
N 3820 -5490 3820 -5470 {
lab=AND[11]}
N 3820 -5470 3880 -5470 {
lab=AND[11]}
N 4170 -5940 4200 -5940 {
lab=OR[0]}
N 4140 -5920 4200 -5920 {
lab=XOR[0]}
N 4170 -5790 4200 -5790 {
lab=OR[1]}
N 4140 -5770 4200 -5770 {
lab=XOR[1]}
N 4170 -5640 4200 -5640 {
lab=OR[2]}
N 4140 -5620 4200 -5620 {
lab=XOR[2]}
N 4170 -5490 4200 -5490 {
lab=OR[3]}
N 4140 -5470 4200 -5470 {
lab=XOR[3]}
N 4170 -5340 4200 -5340 {
lab=OR[4]}
N 4140 -5320 4200 -5320 {
lab=XOR[4]}
N 4170 -5190 4200 -5190 {
lab=OR[5]}
N 4140 -5170 4200 -5170 {
lab=XOR[5]}
N 4170 -5040 4200 -5040 {
lab=OR[6]}
N 4140 -5020 4200 -5020 {
lab=XOR[6]}
N 4170 -4890 4200 -4890 {
lab=OR[7]}
N 4140 -4870 4200 -4870 {
lab=XOR[7]}
N 4170 -4740 4200 -4740 {
lab=OR[8]}
N 4140 -4720 4200 -4720 {
lab=XOR[8]}
N 4170 -4590 4200 -4590 {
lab=OR[9]}
N 4140 -4570 4200 -4570 {
lab=XOR[9]}
N 4170 -4440 4200 -4440 {
lab=OR[10]}
N 4140 -4420 4200 -4420 {
lab=XOR[10]}
N 4170 -4290 4200 -4290 {
lab=OR[11]}
N 4140 -4270 4200 -4270 {
lab=XOR[11]}
N 4170 -4140 4200 -4140 {
lab=OR[12]}
N 4140 -4120 4200 -4120 {
lab=XOR[12]}
N 4170 -3990 4200 -3990 {
lab=OR[13]}
N 4140 -3970 4200 -3970 {
lab=XOR[13]}
N 4170 -3840 4200 -3840 {
lab=OR[14]}
N 4140 -3820 4200 -3820 {
lab=XOR[14]}
N 4170 -3680 4200 -3680 {
lab=AND[15]}
N 4140 -3660 4200 -3660 {
lab=AND[15]}
N 4170 -3530 4200 -3530 {
lab=OR[16]}
N 4140 -3510 4200 -3510 {
lab=XOR[16]}
N 4170 -3390 4200 -3390 {
lab=OR[17]}
N 4140 -3370 4200 -3370 {
lab=XOR[17]}
N 4170 -3230 4200 -3230 {
lab=OR[18]}
N 4140 -3210 4200 -3210 {
lab=XOR[18]}
N 4170 -3080 4200 -3080 {
lab=OR[19]}
N 4140 -3060 4200 -3060 {
lab=XOR[19]}
N 4170 -2930 4200 -2930 {
lab=OR[20]}
N 4140 -2910 4200 -2910 {
lab=XOR[20]}
N 4170 -2780 4200 -2780 {
lab=OR[21]}
N 4140 -2760 4200 -2760 {
lab=XOR[21]}
N 4170 -2630 4200 -2630 {
lab=OR[22]}
N 4140 -2610 4200 -2610 {
lab=XOR[22]}
N 4170 -2480 4200 -2480 {
lab=OR[23]}
N 4140 -2460 4200 -2460 {
lab=XOR[23]}
N 4170 -2330 4200 -2330 {
lab=OR[24]}
N 4140 -2310 4200 -2310 {
lab=XOR[24]}
N 4170 -2180 4200 -2180 {
lab=OR[25]}
N 4140 -2160 4200 -2160 {
lab=XOR[25]}
N 4170 -2030 4200 -2030 {
lab=OR[26]}
N 4140 -2010 4200 -2010 {
lab=XOR[26]}
N 4170 -1880 4200 -1880 {
lab=OR[27]}
N 4140 -1860 4200 -1860 {
lab=XOR[27]}
N 4170 -1730 4200 -1730 {
lab=OR[28]}
N 4140 -1710 4200 -1710 {
lab=XOR[28]}
N 4170 -1580 4200 -1580 {
lab=OR[29]}
N 4140 -1560 4200 -1560 {
lab=XOR[29]}
N 4170 -1430 4200 -1430 {
lab=OR[30]}
N 4140 -1410 4200 -1410 {
lab=XOR[30]}
N 4170 -1280 4200 -1280 {
lab=OR[31]}
N 4140 -1260 4200 -1260 {
lab=XOR[31]}
N 4190 -5980 4190 -1220 {
lab=AND[31:0]
bus=true}
N 4160 -5980 4160 -1220 {
lab=OR[31:0]
bus=true}
N 4130 -5980 4130 -1220 {
lab=XOR[31:0]
bus=true}
N 3300 -5710 3320 -5710 {
lab=B[31:0]}
N 3300 -5690 3320 -5690 {
lab=A[31:0]}
N 3310 -2740 3330 -2740 {
lab=B[31:0]}
N 3310 -2720 3330 -2720 {
lab=A[31:0]}
N 3310 -4190 3330 -4190 {
lab=B[31:0]}
N 4700 -6020 4700 -1260 {
lab=O[31:0]
bus=true}
N 3310 -2750 3310 -2740 {
lab=B[31:0]}
N 3310 -5710 3310 -4190 {
lab=B[31:0]}
N 3310 -4190 3310 -2740 {
lab=B[31:0]}
N 3280 -2720 3310 -2720 {
lab=A[31:0]}
N 3280 -4170 3280 -2720 {
lab=A[31:0]}
N 3280 -4170 3330 -4170 {
lab=A[31:0]}
N 3280 -5690 3280 -4170 {
lab=A[31:0]}
N 3280 -5690 3300 -5690 {
lab=A[31:0]}
N 4400 -6050 4400 -3740 {
lab=S1}
N 4450 -1500 4450 -1350 {
lab=S0}
C {32bit_AND.sym} 3470 -5400 0 0 {name=x1}
C {32bit_OR.sym} 3480 -3880 0 0 {name=x2}
C {32bit_XOR.sym} 3480 -2430 0 0 {name=x3}
C {4x1_mux.sym} 4570 -5930 0 0 {name=x4}
C {4x1_mux.sym} 4570 -5780 0 0 {name=x5}
C {4x1_mux.sym} 4570 -5630 0 0 {name=x6}
C {4x1_mux.sym} 4570 -5480 0 0 {name=x7}
C {4x1_mux.sym} 4570 -5330 0 0 {name=x8}
C {4x1_mux.sym} 4570 -5180 0 0 {name=x9}
C {4x1_mux.sym} 4570 -5030 0 0 {name=x10}
C {4x1_mux.sym} 4570 -4880 0 0 {name=x11}
C {4x1_mux.sym} 4570 -4730 0 0 {name=x12}
C {4x1_mux.sym} 4570 -4580 0 0 {name=x13}
C {4x1_mux.sym} 4570 -4430 0 0 {name=x14}
C {4x1_mux.sym} 4570 -4280 0 0 {name=x15}
C {4x1_mux.sym} 4570 -4130 0 0 {name=x16}
C {4x1_mux.sym} 4570 -3980 0 0 {name=x17}
C {4x1_mux.sym} 4570 -3830 0 0 {name=x18}
C {4x1_mux.sym} 4570 -3670 0 0 {name=x19}
C {4x1_mux.sym} 4570 -3520 0 0 {name=x20}
C {4x1_mux.sym} 4570 -3370 0 0 {name=x21}
C {4x1_mux.sym} 4570 -3220 0 0 {name=x22}
C {4x1_mux.sym} 4570 -3070 0 0 {name=x23}
C {4x1_mux.sym} 4570 -2920 0 0 {name=x24}
C {4x1_mux.sym} 4570 -2770 0 0 {name=x25}
C {4x1_mux.sym} 4570 -2620 0 0 {name=x26}
C {4x1_mux.sym} 4570 -2470 0 0 {name=x27}
C {4x1_mux.sym} 4570 -2320 0 0 {name=x28}
C {4x1_mux.sym} 4570 -2170 0 0 {name=x29}
C {4x1_mux.sym} 4570 -2020 0 0 {name=x30}
C {4x1_mux.sym} 4570 -1870 0 0 {name=x31}
C {4x1_mux.sym} 4570 -1720 0 0 {name=x32}
C {4x1_mux.sym} 4570 -1570 0 0 {name=x33}
C {4x1_mux.sym} 4570 -1420 0 0 {name=x34}
C {4x1_mux.sym} 4570 -1270 0 0 {name=x35}
C {devices/bus_tap.sym} 4190 -5950 0 0 {name=l1 lab=[0]}
C {devices/bus_tap.sym} 4190 -5800 0 0 {name=l2 lab=[1]}
C {devices/bus_tap.sym} 4190 -5650 0 0 {name=l3 lab=[2]}
C {devices/bus_tap.sym} 4190 -5500 0 0 {name=l4 lab=[3]}
C {devices/bus_tap.sym} 4190 -5350 0 0 {name=l5 lab=[4]}
C {devices/bus_tap.sym} 4190 -5200 0 0 {name=l6 lab=[5]}
C {devices/bus_tap.sym} 4190 -5050 0 0 {name=l7 lab=[6]}
C {devices/bus_tap.sym} 4190 -4900 0 0 {name=l8 lab=[7]}
C {devices/bus_tap.sym} 4190 -4750 0 0 {name=l9 lab=[8]}
C {devices/bus_tap.sym} 4190 -4600 0 0 {name=l10 lab=[9]}
C {devices/bus_tap.sym} 4190 -4450 0 0 {name=l11 lab=[10]}
C {devices/bus_tap.sym} 4190 -4300 0 0 {name=l12 lab=[11]}
C {devices/bus_tap.sym} 4190 -4150 0 0 {name=l13 lab=[12]}
C {devices/bus_tap.sym} 4190 -4000 0 0 {name=l14 lab=[13]}
C {devices/bus_tap.sym} 4190 -3850 0 0 {name=l15 lab=[14]}
C {devices/bus_tap.sym} 4190 -3690 0 0 {name=l16 lab=[15]}
C {devices/bus_tap.sym} 4190 -3540 0 0 {name=l17 lab=[16]}
C {devices/bus_tap.sym} 4190 -3400 0 0 {name=l18 lab=[17]}
C {devices/bus_tap.sym} 4190 -3240 0 0 {name=l19 lab=[18]}
C {devices/bus_tap.sym} 4190 -3090 0 0 {name=l20 lab=[19]}
C {devices/bus_tap.sym} 4190 -2940 0 0 {name=l21 lab=[20]}
C {devices/bus_tap.sym} 4190 -2790 0 0 {name=l23 lab=[21]}
C {devices/bus_tap.sym} 4190 -2640 0 0 {name=l24 lab=[22]}
C {devices/bus_tap.sym} 4190 -2490 0 0 {name=l25 lab=[23]}
C {devices/bus_tap.sym} 4190 -2340 0 0 {name=l26 lab=[24]}
C {devices/bus_tap.sym} 4190 -2190 0 0 {name=l27 lab=[25]}
C {devices/bus_tap.sym} 4190 -2040 0 0 {name=l28 lab=[26]}
C {devices/bus_tap.sym} 4190 -1890 0 0 {name=l29 lab=[27]}
C {devices/bus_tap.sym} 4190 -1740 0 0 {name=l30 lab=[28]}
C {devices/bus_tap.sym} 4190 -1590 0 0 {name=l31 lab=[29]}
C {devices/bus_tap.sym} 4190 -1440 0 0 {name=l22 lab=[30]}
C {devices/bus_tap.sym} 4190 -1290 0 0 {name=l32 lab=[31]}
C {devices/bus_tap.sym} 4160 -5930 0 0 {name=l33 lab=[0]}
C {devices/bus_tap.sym} 4160 -5780 0 0 {name=l34 lab=[1]}
C {devices/bus_tap.sym} 4160 -5630 0 0 {name=l35 lab=[2]}
C {devices/bus_tap.sym} 4160 -5480 0 0 {name=l36 lab=[3]}
C {devices/bus_tap.sym} 4160 -5330 0 0 {name=l37 lab=[4]}
C {devices/bus_tap.sym} 4160 -5180 0 0 {name=l38 lab=[5]}
C {devices/bus_tap.sym} 4160 -5030 0 0 {name=l39 lab=[6]}
C {devices/bus_tap.sym} 4160 -4880 0 0 {name=l40 lab=[7]}
C {devices/bus_tap.sym} 4160 -4730 0 0 {name=l41 lab=[8]}
C {devices/bus_tap.sym} 4160 -4580 0 0 {name=l42 lab=[9]}
C {devices/bus_tap.sym} 4160 -4430 0 0 {name=l43 lab=[10]}
C {devices/bus_tap.sym} 4160 -4280 0 0 {name=l44 lab=[11]}
C {devices/bus_tap.sym} 4160 -4130 0 0 {name=l45 lab=[12]}
C {devices/bus_tap.sym} 4160 -3980 0 0 {name=l46 lab=[13]}
C {devices/bus_tap.sym} 4160 -3830 0 0 {name=l47 lab=[14]}
C {devices/bus_tap.sym} 4190 -3670 0 0 {name=l48 lab=[15]}
C {devices/bus_tap.sym} 4160 -3520 0 0 {name=l49 lab=[16]}
C {devices/bus_tap.sym} 4160 -3380 0 0 {name=l50 lab=[17]}
C {devices/bus_tap.sym} 4160 -3220 0 0 {name=l51 lab=[18]}
C {devices/bus_tap.sym} 4160 -3070 0 0 {name=l52 lab=[19]}
C {devices/bus_tap.sym} 4160 -2920 0 0 {name=l53 lab=[20]}
C {devices/bus_tap.sym} 4160 -2770 0 0 {name=l54 lab=[21]}
C {devices/bus_tap.sym} 4160 -2620 0 0 {name=l55 lab=[22]}
C {devices/bus_tap.sym} 4160 -2470 0 0 {name=l56 lab=[23]}
C {devices/bus_tap.sym} 4160 -2320 0 0 {name=l57 lab=[24]}
C {devices/bus_tap.sym} 4160 -2170 0 0 {name=l58 lab=[25]}
C {devices/bus_tap.sym} 4160 -2020 0 0 {name=l59 lab=[26]}
C {devices/bus_tap.sym} 4160 -1870 0 0 {name=l60 lab=[27]}
C {devices/bus_tap.sym} 4160 -1720 0 0 {name=l61 lab=[28]}
C {devices/bus_tap.sym} 4160 -1570 0 0 {name=l62 lab=[29]}
C {devices/bus_tap.sym} 4160 -1420 0 0 {name=l63 lab=[30]}
C {devices/bus_tap.sym} 4160 -1270 0 0 {name=l64 lab=[31]}
C {devices/bus_tap.sym} 4130 -5910 0 0 {name=l65 lab=[0]}
C {devices/bus_tap.sym} 4130 -5760 0 0 {name=l66 lab=[1]}
C {devices/bus_tap.sym} 4130 -5610 0 0 {name=l67 lab=[2]}
C {devices/bus_tap.sym} 4130 -5460 0 0 {name=l68 lab=[3]}
C {devices/bus_tap.sym} 4130 -5310 0 0 {name=l69 lab=[4]}
C {devices/bus_tap.sym} 4130 -5160 0 0 {name=l70 lab=[5]}
C {devices/bus_tap.sym} 4130 -5010 0 0 {name=l71 lab=[6]}
C {devices/bus_tap.sym} 4130 -4860 0 0 {name=l72 lab=[7]}
C {devices/bus_tap.sym} 4130 -4710 0 0 {name=l73 lab=[8]}
C {devices/bus_tap.sym} 4130 -4560 0 0 {name=l74 lab=[9]}
C {devices/bus_tap.sym} 4130 -4410 0 0 {name=l75 lab=[10]}
C {devices/bus_tap.sym} 4130 -4260 0 0 {name=l76 lab=[11]}
C {devices/bus_tap.sym} 4130 -4110 0 0 {name=l77 lab=[12]}
C {devices/bus_tap.sym} 4130 -3960 0 0 {name=l78 lab=[13]}
C {devices/bus_tap.sym} 4130 -3810 0 0 {name=l79 lab=[14]}
C {devices/bus_tap.sym} 4190 -3650 0 0 {name=l80 lab=[15]}
C {devices/bus_tap.sym} 4130 -3500 0 0 {name=l81 lab=[16]}
C {devices/bus_tap.sym} 4130 -3360 0 0 {name=l82 lab=[17]}
C {devices/bus_tap.sym} 4130 -3200 0 0 {name=l83 lab=[18]}
C {devices/bus_tap.sym} 4130 -3050 0 0 {name=l84 lab=[19]}
C {devices/bus_tap.sym} 4130 -2900 0 0 {name=l85 lab=[20]}
C {devices/bus_tap.sym} 4130 -2750 0 0 {name=l86 lab=[21]}
C {devices/bus_tap.sym} 4130 -2600 0 0 {name=l87 lab=[22]}
C {devices/bus_tap.sym} 4130 -2450 0 0 {name=l88 lab=[23]}
C {devices/bus_tap.sym} 4130 -2300 0 0 {name=l89 lab=[24]}
C {devices/bus_tap.sym} 4130 -2150 0 0 {name=l90 lab=[25]}
C {devices/bus_tap.sym} 4130 -2000 0 0 {name=l91 lab=[26]}
C {devices/bus_tap.sym} 4130 -1850 0 0 {name=l92 lab=[27]}
C {devices/bus_tap.sym} 4130 -1700 0 0 {name=l93 lab=[28]}
C {devices/bus_tap.sym} 4130 -1550 0 0 {name=l94 lab=[29]}
C {devices/bus_tap.sym} 4130 -1400 0 0 {name=l95 lab=[30]}
C {devices/bus_tap.sym} 4130 -1250 0 0 {name=l96 lab=[31]}
C {devices/bus_tap.sym} 3900 -2930 0 1 {name=l97 lab=[0]}
C {devices/bus_tap.sym} 3900 -2890 0 1 {name=l98 lab=[1]}
C {devices/bus_tap.sym} 3900 -2850 0 1 {name=l99 lab=[2]}
C {devices/bus_tap.sym} 3900 -2810 0 1 {name=l100 lab=[3]}
C {devices/bus_tap.sym} 3900 -2770 0 1 {name=l101 lab=[4]}
C {devices/bus_tap.sym} 3900 -2730 0 1 {name=l102 lab=[5]}
C {devices/bus_tap.sym} 3900 -2690 0 1 {name=l103 lab=[6]}
C {devices/bus_tap.sym} 3900 -2650 0 1 {name=l104 lab=[7]}
C {devices/bus_tap.sym} 3900 -2610 0 1 {name=l105 lab=[8]}
C {devices/bus_tap.sym} 3900 -2570 0 1 {name=l106 lab=[9]}
C {devices/bus_tap.sym} 3900 -2530 0 1 {name=l107 lab=[10]}
C {devices/bus_tap.sym} 3900 -2490 0 1 {name=l108 lab=[11]}
C {devices/bus_tap.sym} 3900 -2450 0 1 {name=l109 lab=[12]}
C {devices/bus_tap.sym} 3900 -2410 0 1 {name=l110 lab=[13]}
C {devices/bus_tap.sym} 3900 -2370 0 1 {name=l111 lab=[14]}
C {devices/bus_tap.sym} 3900 -2330 0 1 {name=l112 lab=[15]}
C {devices/bus_tap.sym} 3900 -2290 0 1 {name=l113 lab=[16]}
C {devices/bus_tap.sym} 3900 -2250 0 1 {name=l114 lab=[17]}
C {devices/bus_tap.sym} 3900 -2210 0 1 {name=l115 lab=[18]}
C {devices/bus_tap.sym} 3900 -2170 0 1 {name=l116 lab=[19]}
C {devices/bus_tap.sym} 3900 -2130 0 1 {name=l117 lab=[20]}
C {devices/bus_tap.sym} 3900 -2090 0 1 {name=l118 lab=[21]}
C {devices/bus_tap.sym} 3900 -2050 0 1 {name=l119 lab=[22]}
C {devices/bus_tap.sym} 3900 -2010 0 1 {name=l120 lab=[23]}
C {devices/bus_tap.sym} 3900 -1970 0 1 {name=l121 lab=[24]}
C {devices/bus_tap.sym} 3900 -1930 0 1 {name=l122 lab=[25]}
C {devices/bus_tap.sym} 3900 -1890 0 1 {name=l123 lab=[26]}
C {devices/bus_tap.sym} 3900 -1850 0 1 {name=l124 lab=[27]}
C {devices/bus_tap.sym} 3900 -1810 0 1 {name=l125 lab=[28]}
C {devices/bus_tap.sym} 3900 -1770 0 1 {name=l126 lab=[29]}
C {devices/bus_tap.sym} 3900 -1720 0 1 {name=l127 lab=[30]}
C {devices/bus_tap.sym} 3900 -1680 0 1 {name=l128 lab=[31]}
C {devices/bus_tap.sym} 3900 -4380 0 1 {name=l129 lab=[0]}
C {devices/bus_tap.sym} 3900 -4340 0 1 {name=l130 lab=[1]}
C {devices/bus_tap.sym} 3900 -4300 0 1 {name=l131 lab=[2]}
C {devices/bus_tap.sym} 3900 -4260 0 1 {name=l132 lab=[3]}
C {devices/bus_tap.sym} 3900 -4220 0 1 {name=l133 lab=[4]}
C {devices/bus_tap.sym} 3900 -4180 0 1 {name=l134 lab=[5]}
C {devices/bus_tap.sym} 3900 -4140 0 1 {name=l135 lab=[6]}
C {devices/bus_tap.sym} 3900 -4100 0 1 {name=l136 lab=[7]}
C {devices/bus_tap.sym} 3900 -4060 0 1 {name=l137 lab=[8]}
C {devices/bus_tap.sym} 3900 -4020 0 1 {name=l138 lab=[9]}
C {devices/bus_tap.sym} 3900 -3980 0 1 {name=l139 lab=[10]}
C {devices/bus_tap.sym} 3900 -3940 0 1 {name=l140 lab=[11]}
C {devices/bus_tap.sym} 3900 -3900 0 1 {name=l141 lab=[12]}
C {devices/bus_tap.sym} 3900 -3860 0 1 {name=l142 lab=[13]}
C {devices/bus_tap.sym} 3900 -3820 0 1 {name=l143 lab=[14]}
C {devices/bus_tap.sym} 3900 -3780 0 1 {name=l144 lab=[15]}
C {devices/bus_tap.sym} 3900 -3740 0 1 {name=l145 lab=[16]}
C {devices/bus_tap.sym} 3900 -3700 0 1 {name=l146 lab=[17]}
C {devices/bus_tap.sym} 3900 -3660 0 1 {name=l147 lab=[18]}
C {devices/bus_tap.sym} 3900 -3620 0 1 {name=l148 lab=[19]}
C {devices/bus_tap.sym} 3900 -3580 0 1 {name=l149 lab=[20]}
C {devices/bus_tap.sym} 3900 -3540 0 1 {name=l150 lab=[21]}
C {devices/bus_tap.sym} 3900 -3500 0 1 {name=l151 lab=[22]}
C {devices/bus_tap.sym} 3900 -3460 0 1 {name=l152 lab=[23]}
C {devices/bus_tap.sym} 3900 -3420 0 1 {name=l153 lab=[24]}
C {devices/bus_tap.sym} 3900 -3380 0 1 {name=l154 lab=[25]}
C {devices/bus_tap.sym} 3900 -3340 0 1 {name=l155 lab=[26]}
C {devices/bus_tap.sym} 3900 -3300 0 1 {name=l156 lab=[27]}
C {devices/bus_tap.sym} 3900 -3260 0 1 {name=l157 lab=[28]}
C {devices/bus_tap.sym} 3900 -3220 0 1 {name=l158 lab=[29]}
C {devices/bus_tap.sym} 3900 -3170 0 1 {name=l159 lab=[30]}
C {devices/bus_tap.sym} 3900 -3130 0 1 {name=l160 lab=[31]}
C {devices/bus_tap.sym} 3890 -5900 0 1 {name=l161 lab=[0]}
C {devices/bus_tap.sym} 3890 -5860 0 1 {name=l162 lab=[1]}
C {devices/bus_tap.sym} 3890 -5820 0 1 {name=l163 lab=[2]}
C {devices/bus_tap.sym} 3890 -5780 0 1 {name=l164 lab=[3]}
C {devices/bus_tap.sym} 3890 -5740 0 1 {name=l165 lab=[4]}
C {devices/bus_tap.sym} 3890 -5700 0 1 {name=l166 lab=[5]}
C {devices/bus_tap.sym} 3890 -5660 0 1 {name=l167 lab=[6]}
C {devices/bus_tap.sym} 3890 -5620 0 1 {name=l168 lab=[7]}
C {devices/bus_tap.sym} 3890 -5580 0 1 {name=l169 lab=[8]}
C {devices/bus_tap.sym} 3890 -5540 0 1 {name=l170 lab=[9]}
C {devices/bus_tap.sym} 3890 -5500 0 1 {name=l171 lab=[10]}
C {devices/bus_tap.sym} 3890 -5460 0 1 {name=l172 lab=[11]}
C {devices/bus_tap.sym} 3890 -5420 0 1 {name=l173 lab=[12]}
C {devices/bus_tap.sym} 3890 -5380 0 1 {name=l174 lab=[13]}
C {devices/bus_tap.sym} 3890 -5340 0 1 {name=l175 lab=[14]}
C {devices/bus_tap.sym} 3890 -5300 0 1 {name=l176 lab=[15]}
C {devices/bus_tap.sym} 3890 -5260 0 1 {name=l177 lab=[16]}
C {devices/bus_tap.sym} 3890 -5220 0 1 {name=l178 lab=[17]}
C {devices/bus_tap.sym} 3890 -5180 0 1 {name=l179 lab=[18]}
C {devices/bus_tap.sym} 3890 -5140 0 1 {name=l180 lab=[19]}
C {devices/bus_tap.sym} 3890 -5100 0 1 {name=l181 lab=[20]}
C {devices/bus_tap.sym} 3890 -5060 0 1 {name=l182 lab=[21]}
C {devices/bus_tap.sym} 3890 -5020 0 1 {name=l183 lab=[22]}
C {devices/bus_tap.sym} 3890 -4980 0 1 {name=l184 lab=[23]}
C {devices/bus_tap.sym} 3890 -4940 0 1 {name=l185 lab=[24]}
C {devices/bus_tap.sym} 3890 -4900 0 1 {name=l186 lab=[25]}
C {devices/bus_tap.sym} 3890 -4860 0 1 {name=l187 lab=[26]}
C {devices/bus_tap.sym} 3890 -4820 0 1 {name=l188 lab=[27]}
C {devices/bus_tap.sym} 3890 -4780 0 1 {name=l189 lab=[28]}
C {devices/bus_tap.sym} 3890 -4740 0 1 {name=l190 lab=[29]}
C {devices/bus_tap.sym} 3890 -4690 0 1 {name=l191 lab=[30]}
C {devices/bus_tap.sym} 3890 -4650 0 1 {name=l192 lab=[31]}
C {devices/bus_tap.sym} 4700 -5980 0 1 {name=l193 lab=[0]}
C {devices/bus_tap.sym} 4700 -5830 0 1 {name=l194 lab=[1]}
C {devices/bus_tap.sym} 4700 -5680 0 1 {name=l195 lab=[2]}
C {devices/bus_tap.sym} 4700 -5530 0 1 {name=l196 lab=[3]}
C {devices/bus_tap.sym} 4700 -5380 0 1 {name=l197 lab=[4]}
C {devices/bus_tap.sym} 4700 -5230 0 1 {name=l198 lab=[5]}
C {devices/bus_tap.sym} 4700 -5080 0 1 {name=l199 lab=[6]}
C {devices/bus_tap.sym} 4700 -4930 0 1 {name=l200 lab=[7]}
C {devices/bus_tap.sym} 4700 -4780 0 1 {name=l201 lab=[8]}
C {devices/bus_tap.sym} 4700 -4630 0 1 {name=l202 lab=[9]}
C {devices/bus_tap.sym} 4700 -4480 0 1 {name=l203 lab=[10]}
C {devices/bus_tap.sym} 4700 -4330 0 1 {name=l204 lab=[11]}
C {devices/bus_tap.sym} 4700 -4180 0 1 {name=l205 lab=[12]}
C {devices/bus_tap.sym} 4700 -4030 0 1 {name=l206 lab=[13]}
C {devices/bus_tap.sym} 4700 -3880 0 1 {name=l207 lab=[14]}
C {devices/bus_tap.sym} 4700 -3720 0 1 {name=l208 lab=[15]}
C {devices/bus_tap.sym} 4700 -3570 0 1 {name=l209 lab=[16]}
C {devices/bus_tap.sym} 4700 -3420 0 1 {name=l210 lab=[17]}
C {devices/bus_tap.sym} 4700 -3270 0 1 {name=l211 lab=[18]}
C {devices/bus_tap.sym} 4700 -3120 0 1 {name=l212 lab=[19]}
C {devices/bus_tap.sym} 4700 -2970 0 1 {name=l213 lab=[20]}
C {devices/bus_tap.sym} 4700 -2820 0 1 {name=l214 lab=[21]}
C {devices/bus_tap.sym} 4700 -2670 0 1 {name=l215 lab=[22]}
C {devices/bus_tap.sym} 4700 -2520 0 1 {name=l216 lab=[23]}
C {devices/bus_tap.sym} 4700 -2370 0 1 {name=l217 lab=[24]}
C {devices/bus_tap.sym} 4700 -2220 0 1 {name=l218 lab=[25]}
C {devices/bus_tap.sym} 4700 -2070 0 1 {name=l219 lab=[26]}
C {devices/bus_tap.sym} 4700 -1920 0 1 {name=l220 lab=[27]}
C {devices/bus_tap.sym} 4700 -1770 0 1 {name=l221 lab=[28]}
C {devices/bus_tap.sym} 4700 -1620 0 1 {name=l222 lab=[29]}
C {devices/bus_tap.sym} 4700 -1470 0 1 {name=l223 lab=[30]}
C {devices/bus_tap.sym} 4700 -1320 0 1 {name=l224 lab=[31]}
C {devices/bus_tap.sym} 4190 -5960 0 0 {name=l225 lab=[0]}
C {devices/ipin.sym} 3280 -5690 0 0 {name=p16 sig_type=std_logic lab=A[31:0]}
C {devices/ipin.sym} 3300 -5710 0 0 {name=p17 sig_type=std_logic lab=B[31:0]}
C {devices/ipin.sym} 3890 -5920 1 0 {name=p5 sig_type=std_logic lab=AND[31:0]}
C {devices/ipin.sym} 3900 -2950 1 0 {name=p6 sig_type=std_logic lab=XOR[31:0]}
C {devices/ipin.sym} 3900 -4400 1 0 {name=p7 sig_type=std_logic lab=OR[31:0]}
C {devices/ipin.sym} 4190 -5980 1 0 {name=p8 sig_type=std_logic lab=AND[31:0]}
C {devices/ipin.sym} 4130 -5980 1 0 {name=p9 sig_type=std_logic lab=XOR[31:0]}
C {devices/ipin.sym} 4160 -5980 1 0 {name=p10 sig_type=std_logic lab=OR[31:0]}
C {devices/ipin.sym} 4700 -6020 1 0 {name=p11 sig_type=std_logic lab=O[31:0]}
C {devices/ipin.sym} 4450 -6050 1 0 {name=p12 sig_type=std_logic lab=S0}
C {devices/ipin.sym} 4400 -6050 1 0 {name=p13 sig_type=std_logic lab=S1}
