v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 1430 -2420 1760 -2420 {
lab=#net1}
N 1760 -2470 1760 -2420 {
lab=#net1}
N 1760 -2470 1870 -2470 {
lab=#net1}
N 1430 -2400 1570 -2400 {
lab=#net2}
N 1650 -2390 1770 -2390 {
lab=#net3}
N 1770 -2450 1770 -2390 {
lab=#net3}
N 1770 -2450 1870 -2450 {
lab=#net3}
N 1430 -2340 1510 -2340 {
lab=#net4}
N 1510 -2380 1510 -2340 {
lab=#net4}
N 1510 -2380 1570 -2380 {
lab=#net4}
N 1430 -2320 1570 -2320 {
lab=#net5}
N 1520 -2340 1570 -2340 {
lab=#net2}
N 1520 -2400 1520 -2340 {
lab=#net2}
N 1430 -2380 1480 -2380 {
lab=#net6}
N 1480 -2380 1480 -2360 {
lab=#net6}
N 1480 -2360 1870 -2360 {
lab=#net6}
N 1520 -2340 1520 -2280 {
lab=#net2}
N 1520 -2280 1570 -2280 {
lab=#net2}
N 1500 -2260 1570 -2260 {
lab=#net7}
N 1500 -2300 1500 -2260 {
lab=#net7}
N 1430 -2300 1500 -2300 {
lab=#net7}
N 1650 -2270 1760 -2270 {
lab=#net8}
N 1760 -2340 1760 -2270 {
lab=#net8}
N 1760 -2340 1870 -2340 {
lab=#net8}
N 1650 -2330 1690 -2330 {
lab=#net9}
N 1690 -2330 1690 -2220 {
lab=#net9}
N 1690 -2220 1710 -2220 {
lab=#net9}
N 1430 -2200 1710 -2200 {
lab=#net10}
N 1690 -2380 1690 -2330 {
lab=#net9}
N 1780 -2430 1810 -2430 {
lab=#net9}
N 1780 -2430 1780 -2380 {
lab=#net9}
N 1690 -2380 1780 -2380 {
lab=#net9}
N 1500 -2240 1780 -2240 {
lab=#net11}
N 1780 -2240 1790 -2240 {
lab=#net11}
N 1790 -2410 1790 -2240 {
lab=#net11}
N 1790 -2410 1810 -2410 {
lab=#net11}
N 1810 -2430 1840 -2430 {
lab=#net9}
N 1810 -2410 1840 -2410 {
lab=#net11}
N 1780 -2380 1820 -2380 {
lab=#net9}
N 1820 -2380 1820 -2320 {
lab=#net9}
N 1820 -2320 1840 -2320 {
lab=#net9}
N 1820 -2300 1840 -2300 {
lab=#net12}
N 1790 -2210 1840 -2210 {
lab=#net13}
N 1830 -2230 1830 -2210 {
lab=#net13}
N 1830 -2230 1990 -2230 {
lab=#net13}
N 1870 -2470 2130 -2470 {
lab=#net1}
N 1870 -2450 2130 -2450 {
lab=#net3}
N 1870 -2360 2130 -2360 {
lab=#net6}
N 1870 -2340 2130 -2340 {
lab=#net8}
N 1920 -2200 1940 -2200 {
lab=#net14}
N 1940 -2410 1940 -2200 {
lab=#net14}
N 1940 -2410 2130 -2410 {
lab=#net14}
N 2070 -2220 2090 -2220 {
lab=#net15}
N 2090 -2300 2090 -2220 {
lab=#net15}
N 2090 -2300 2130 -2300 {
lab=#net15}
N 1810 -2300 1820 -2300 {
lab=#net12}
N 1800 -2300 1810 -2300 {
lab=#net12}
N 1800 -2300 1800 -2180 {
lab=#net12}
N 1430 -2180 1800 -2180 {
lab=#net12}
N 1810 -2190 1840 -2190 {
lab=#net16}
N 1810 -2190 1810 -2110 {
lab=#net16}
N 1430 -2110 1810 -2110 {
lab=#net16}
N 1830 -2210 1830 -2120 {
lab=#net13}
N 1430 -2090 1840 -2090 {
lab=#net17}
N 1430 -2070 1970 -2070 {
lab=#net18}
N 1970 -2210 1970 -2070 {
lab=#net18}
N 1970 -2210 1990 -2210 {
lab=#net18}
N 1920 -2100 2320 -2100 {
lab=E}
N 2280 -2330 2320 -2330 {
lab=G}
N 2280 -2440 2320 -2440 {
lab=L}
N 1920 -2420 1940 -2420 {
lab=#net19}
N 1940 -2430 1940 -2420 {
lab=#net19}
N 1940 -2430 2130 -2430 {
lab=#net19}
N 1920 -2310 2000 -2310 {
lab=#net20}
N 2000 -2320 2000 -2310 {
lab=#net20}
N 2000 -2320 2130 -2320 {
lab=#net20}
N 1830 -2120 1830 -2110 {
lab=#net13}
N 1830 -2110 1840 -2110 {
lab=#net13}
N 650 -2640 739 -2640 {
lab=#net21}
N 650 -2530 740 -2530 {
lab=#net22}
N 540 -2640 590 -2640 {
lab=A[0]}
N 530 -2530 590 -2530 {
lab=B[0]}
N 570 -2640 570 -2610 {
lab=A[0]}
N 570 -2610 710 -2550 {
lab=A[0]}
N 710 -2550 740 -2550 {
lab=A[0]}
N 710 -2620 740 -2620 {
lab=B[0]}
N 570 -2550 710 -2620 {
lab=B[0]}
N 570 -2550 570 -2530 {
lab=B[0]}
N 820 -2630 850 -2630 {
lab=#net1}
N 850 -2630 850 -2600 {
lab=#net1}
N 850 -2600 920 -2600 {
lab=#net1}
N 850 -2580 920 -2580 {
lab=#net6}
N 850 -2580 850 -2540 {
lab=#net6}
N 820 -2540 850 -2540 {
lab=#net6}
N 1050 -2590 1090 -2590 {
lab=#net2}
N 850 -2540 850 -2520 {
lab=#net6}
N 850 -2520 1090 -2520 {
lab=#net6}
N 850 -2660 850 -2630 {
lab=#net1}
N 850 -2660 1090 -2660 {
lab=#net1}
N 1430 -2660 1430 -2420 {
lab=#net1}
N 1090 -2660 1430 -2660 {
lab=#net1}
N 1090 -2590 1410 -2590 {
lab=#net2}
N 1410 -2590 1410 -2400 {
lab=#net2}
N 1410 -2400 1430 -2400 {
lab=#net2}
N 1400 -2380 1430 -2380 {
lab=#net6}
N 1400 -2520 1400 -2380 {
lab=#net6}
N 1090 -2520 1400 -2520 {
lab=#net6}
N 650 -2490 739 -2490 {
lab=#net23}
N 650 -2380 740 -2380 {
lab=#net24}
N 540 -2490 590 -2490 {
lab=A[1]}
N 530 -2380 590 -2380 {
lab=B[1]}
N 570 -2490 570 -2460 {
lab=A[1]}
N 570 -2460 710 -2400 {
lab=A[1]}
N 710 -2400 740 -2400 {
lab=A[1]}
N 710 -2470 740 -2470 {
lab=B[1]}
N 570 -2400 710 -2470 {
lab=B[1]}
N 570 -2400 570 -2380 {
lab=B[1]}
N 820 -2480 850 -2480 {
lab=#net4}
N 850 -2480 850 -2450 {
lab=#net4}
N 850 -2450 920 -2450 {
lab=#net4}
N 850 -2430 920 -2430 {
lab=#net7}
N 850 -2430 850 -2390 {
lab=#net7}
N 820 -2390 850 -2390 {
lab=#net7}
N 1050 -2440 1090 -2440 {
lab=#net5}
N 850 -2390 850 -2370 {
lab=#net7}
N 850 -2370 1090 -2370 {
lab=#net7}
N 850 -2510 850 -2480 {
lab=#net4}
N 850 -2510 1090 -2510 {
lab=#net4}
N 1390 -2340 1430 -2340 {
lab=#net4}
N 1390 -2510 1390 -2340 {
lab=#net4}
N 1090 -2510 1390 -2510 {
lab=#net4}
N 1090 -2440 1380 -2440 {
lab=#net5}
N 1380 -2440 1380 -2320 {
lab=#net5}
N 1380 -2320 1430 -2320 {
lab=#net5}
N 1360 -2300 1430 -2300 {
lab=#net7}
N 1360 -2370 1360 -2300 {
lab=#net7}
N 1090 -2370 1360 -2370 {
lab=#net7}
N 650 -2340 739 -2340 {
lab=#net25}
N 650 -2230 740 -2230 {
lab=#net26}
N 540 -2340 590 -2340 {
lab=A[2]}
N 530 -2230 590 -2230 {
lab=B[2]}
N 570 -2340 570 -2310 {
lab=A[2]}
N 570 -2310 710 -2250 {
lab=A[2]}
N 710 -2250 740 -2250 {
lab=A[2]}
N 710 -2320 740 -2320 {
lab=B[2]}
N 570 -2250 710 -2320 {
lab=B[2]}
N 570 -2250 570 -2230 {
lab=B[2]}
N 820 -2330 850 -2330 {
lab=#net11}
N 850 -2330 850 -2300 {
lab=#net11}
N 850 -2300 920 -2300 {
lab=#net11}
N 850 -2280 920 -2280 {
lab=#net12}
N 850 -2280 850 -2240 {
lab=#net12}
N 820 -2240 850 -2240 {
lab=#net12}
N 1050 -2290 1090 -2290 {
lab=#net10}
N 850 -2240 850 -2220 {
lab=#net12}
N 850 -2220 1090 -2220 {
lab=#net12}
N 850 -2360 850 -2330 {
lab=#net11}
N 850 -2360 1090 -2360 {
lab=#net11}
N 650 -2190 739 -2190 {
lab=#net27}
N 650 -2080 740 -2080 {
lab=#net28}
N 540 -2190 590 -2190 {
lab=A[3]}
N 530 -2080 590 -2080 {
lab=B[3]}
N 570 -2190 570 -2160 {
lab=A[3]}
N 570 -2160 710 -2100 {
lab=A[3]}
N 710 -2100 740 -2100 {
lab=A[3]}
N 710 -2170 740 -2170 {
lab=B[3]}
N 570 -2100 710 -2170 {
lab=B[3]}
N 570 -2100 570 -2080 {
lab=B[3]}
N 820 -2180 850 -2180 {
lab=#net16}
N 850 -2180 850 -2150 {
lab=#net16}
N 850 -2150 920 -2150 {
lab=#net16}
N 850 -2130 920 -2130 {
lab=#net18}
N 850 -2130 850 -2090 {
lab=#net18}
N 820 -2090 850 -2090 {
lab=#net18}
N 1050 -2140 1090 -2140 {
lab=#net17}
N 850 -2090 850 -2070 {
lab=#net18}
N 850 -2070 1090 -2070 {
lab=#net18}
N 850 -2210 850 -2180 {
lab=#net16}
N 850 -2210 1090 -2210 {
lab=#net16}
N 1350 -2240 1500 -2240 {
lab=#net11}
N 1350 -2360 1350 -2240 {
lab=#net11}
N 1090 -2360 1350 -2360 {
lab=#net11}
N 1090 -2290 1340 -2290 {
lab=#net10}
N 1340 -2290 1340 -2200 {
lab=#net10}
N 1340 -2200 1430 -2200 {
lab=#net10}
N 1090 -2220 1330 -2220 {
lab=#net12}
N 1330 -2220 1330 -2180 {
lab=#net12}
N 1330 -2180 1430 -2180 {
lab=#net12}
N 1090 -2210 1320 -2210 {
lab=#net16}
N 1320 -2210 1320 -2110 {
lab=#net16}
N 1320 -2110 1430 -2110 {
lab=#net16}
N 1310 -2090 1430 -2090 {
lab=#net17}
N 1310 -2140 1310 -2090 {
lab=#net17}
N 1090 -2140 1310 -2140 {
lab=#net17}
N 1090 -2070 1430 -2070 {
lab=#net18}
N 440 -2680 440 -2060 {bus=true lab=A[3:0]}
N 370 -2570 370 -1950 {bus=true lab=B[3:0]}
N 450 -2640 540 -2640 {
lab=A[0]}
N 380 -2530 530 -2530 {
lab=B[0]}
N 450 -2490 540 -2490 {
lab=A[1]}
N 380 -2380 530 -2380 {
lab=B[1]}
N 450 -2340 540 -2340 {
lab=A[2]}
N 380 -2230 530 -2230 {
lab=B[2]}
N 450 -2190 540 -2190 {
lab=A[3]}
N 380 -2080 530 -2080 {
lab=B[3]}
C {AND2.sym} 1610 -2390 0 0 {name=x5}
C {AND2.sym} 1610 -2330 0 0 {name=x6}
C {AND2.sym} 1610 -2270 0 0 {name=x7}
C {AND2.sym} 1880 -2100 0 0 {name=x8}
C {AND2.sym} 1880 -2200 0 0 {name=x9}
C {AND2.sym} 2030 -2220 0 0 {name=x10}
C {AND2.sym} 1750 -2210 0 0 {name=x11}
C {AND2.sym} 1880 -2420 0 0 {name=x12}
C {AND2.sym} 1880 -2310 0 0 {name=x13}
C {OR4.sym} 2280 -2440 0 0 {name=x14}
C {OR4.sym} 2280 -2330 0 0 {name=x15}
C {devices/opin.sym} 2320 -2440 0 0 {name=p1 sig_type=std_logic lab=L}
C {devices/opin.sym} 2320 -2330 0 0 {name=p2 sig_type=std_logic lab=G}
C {devices/opin.sym} 2320 -2100 0 0 {name=p3 sig_type=std_logic lab=E}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 620 -2640 0 0 {name=X1}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 620 -2530 0 0 {name=X2}
C {AND2.sym} 780 -2630 0 0 {name=x3}
C {AND2.sym} 780 -2540 0 0 {name=x16}
C {NOR2.sym} 980 -2590 0 0 {name=x17}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 620 -2490 0 0 {name=X18}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 620 -2380 0 0 {name=X19}
C {AND2.sym} 780 -2480 0 0 {name=x20}
C {AND2.sym} 780 -2390 0 0 {name=x21}
C {NOR2.sym} 980 -2440 0 0 {name=x22}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 620 -2340 0 0 {name=X23}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 620 -2230 0 0 {name=X24}
C {AND2.sym} 780 -2330 0 0 {name=x25}
C {AND2.sym} 780 -2240 0 0 {name=x26}
C {NOR2.sym} 980 -2290 0 0 {name=x27}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 620 -2190 0 0 {name=X28}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 620 -2080 0 0 {name=X29}
C {AND2.sym} 780 -2180 0 0 {name=x30}
C {AND2.sym} 780 -2090 0 0 {name=x31}
C {NOR2.sym} 980 -2140 0 0 {name=x32}
C {devices/bus_tap.sym} 440 -2630 0 0 {name=l1 lab=[0]}
C {devices/bus_tap.sym} 440 -2480 0 0 {name=l2 lab=[1]}
C {devices/bus_tap.sym} 440 -2330 0 0 {name=l3 lab=[2]}
C {devices/bus_tap.sym} 440 -2180 0 0 {name=l4 lab=[3]}
C {devices/ipin.sym} 440 -2680 1 0 {name=p16 sig_type=std_logic lab=A[3:0]}
C {devices/bus_tap.sym} 370 -2520 0 0 {name=l5 lab=[0]}
C {devices/bus_tap.sym} 370 -2370 0 0 {name=l6 lab=[1]}
C {devices/bus_tap.sym} 370 -2220 0 0 {name=l7 lab=[2]}
C {devices/bus_tap.sym} 370 -2070 0 0 {name=l8 lab=[3]}
C {devices/ipin.sym} 370 -2570 1 0 {name=p17 sig_type=std_logic lab=B[3:0]}
