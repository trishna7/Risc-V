v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/home/apn/test_xschem_sky130/d-flipflop.sym} -60 -10 0 0 {name=x1}
