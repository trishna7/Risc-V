v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
B 2 3660 -5990 4460 -5590 {flags=graph
y1=0
y2=2
ypos1=-0.4
ypos2=1.6
divy=5
subdivy=1
unity=1
x1=6.5e-08
x2=1.65e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
digital=1

color="10 10 10 10"
node="sel;s0,s1
s
a;a[31],a[30],a[29],a[28],a[27],a[26],a[25],a[24],a[23],a[22],a[21],a[20],a[19],a[18],a[17],a[16],a[15],a[14],a[13],a[12],a[11],a[10],a[9],a[8],a[7],a[6],a[5],a[4],a[3],a[2],a[1],a[0]
o;o[31],o[30],o[29],o[28],o[27],o[26],o[25],o[24],o[23],o[22],o[21],o[20],o[19],o[18],o[17],o[16],o[15],o[14],o[13],o[12],o[11],o[10],o[9],o[8],o[7],o[6],o[5],o[4],o[3],o[2],o[1],o[0]"}
B 2 3660 -6430 4460 -6030 {flags=graph
y1=0
y2=2
ypos1=-0.4
ypos2=1.6
divy=5
subdivy=1
unity=1
x1=6.5e-08
x2=1.65e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
digital=1


color="4 4"
node="l;a[2],a[1],a[0],l
1st;net6,net5,net4,net3"}
N 2850 -7760 2850 -5450 {
lab=S0}
N 2850 -7720 2900 -7720 {
lab=S0}
N 2800 -7700 2900 -7700 {
lab=S1}
N 2850 -7570 2900 -7570 {
lab=S0}
N 2800 -7550 2900 -7550 {
lab=S1}
N 2850 -7420 2900 -7420 {
lab=S0}
N 2800 -7400 2900 -7400 {
lab=S1}
N 2850 -7270 2900 -7270 {
lab=S0}
N 2800 -7250 2900 -7250 {
lab=S1}
N 2850 -7120 2900 -7120 {
lab=S0}
N 2800 -7100 2900 -7100 {
lab=S1}
N 2850 -6970 2900 -6970 {
lab=S0}
N 2800 -6950 2900 -6950 {
lab=S1}
N 2850 -6820 2900 -6820 {
lab=S0}
N 2800 -6800 2900 -6800 {
lab=S1}
N 2850 -6670 2900 -6670 {
lab=S0}
N 2800 -6650 2900 -6650 {
lab=S1}
N 2850 -6520 2900 -6520 {
lab=S0}
N 2800 -6500 2900 -6500 {
lab=S1}
N 2850 -6370 2900 -6370 {
lab=S0}
N 2800 -6350 2900 -6350 {
lab=S1}
N 2850 -6220 2900 -6220 {
lab=S0}
N 2800 -6200 2900 -6200 {
lab=S1}
N 2850 -6070 2900 -6070 {
lab=S0}
N 2800 -6050 2900 -6050 {
lab=S1}
N 2850 -5920 2900 -5920 {
lab=S0}
N 2800 -5900 2900 -5900 {
lab=S1}
N 2850 -5770 2900 -5770 {
lab=S0}
N 2800 -5750 2900 -5750 {
lab=S1}
N 2850 -5620 2900 -5620 {
lab=S0}
N 2800 -5600 2900 -5600 {
lab=S1}
N 2850 -5500 2850 -3190 {
lab=S0}
N 2850 -5460 2900 -5460 {
lab=S0}
N 2800 -5440 2900 -5440 {
lab=S1}
N 2850 -5310 2900 -5310 {
lab=S0}
N 2800 -5290 2900 -5290 {
lab=S1}
N 2850 -5160 2900 -5160 {
lab=S0}
N 2800 -5140 2900 -5140 {
lab=S1}
N 2850 -5010 2900 -5010 {
lab=S0}
N 2800 -4990 2900 -4990 {
lab=S1}
N 2850 -4860 2900 -4860 {
lab=S0}
N 2800 -4840 2900 -4840 {
lab=S1}
N 2850 -4710 2900 -4710 {
lab=S0}
N 2800 -4690 2900 -4690 {
lab=S1}
N 2850 -4560 2900 -4560 {
lab=S0}
N 2800 -4540 2900 -4540 {
lab=S1}
N 2850 -4410 2900 -4410 {
lab=S0}
N 2800 -4390 2900 -4390 {
lab=S1}
N 2850 -4260 2900 -4260 {
lab=S0}
N 2800 -4240 2900 -4240 {
lab=S1}
N 2850 -4110 2900 -4110 {
lab=S0}
N 2800 -4090 2900 -4090 {
lab=S1}
N 2850 -3960 2900 -3960 {
lab=S0}
N 2800 -3940 2900 -3940 {
lab=S1}
N 2850 -3810 2900 -3810 {
lab=S0}
N 2800 -3790 2900 -3790 {
lab=S1}
N 2850 -3660 2900 -3660 {
lab=S0}
N 2800 -3640 2900 -3640 {
lab=S1}
N 2850 -3510 2900 -3510 {
lab=S0}
N 2800 -3490 2900 -3490 {
lab=S1}
N 2850 -3360 2900 -3360 {
lab=S0}
N 2800 -3340 2900 -3340 {
lab=S1}
N 2000 -7740 2000 -3180 {
lab=A[0]}
N 1920 -7740 1920 -3180 {
lab=A[2]}
N 1840 -7740 1840 -3180 {
lab=A[4]}
N 1760 -7740 1760 -3180 {
lab=A[6]}
N 1680 -7740 1680 -3180 {
lab=A[8]}
N 1600 -7740 1600 -3180 {
lab=A[10]}
N 1520 -7740 1520 -3180 {
lab=A[12]}
N 1440 -7740 1440 -3180 {
lab=A[14]}
N 1360 -7740 1360 -3180 {
lab=A[16]}
N 1280 -7740 1280 -3180 {
lab=A[18]}
N 1200 -7740 1200 -3180 {
lab=A[20]}
N 1120 -7740 1120 -3180 {
lab=A[22]}
N 1040 -7740 1040 -3180 {
lab=A[24]}
N 960 -7740 960 -3180 {
lab=A[26]}
N 880 -7740 880 -3180 {
lab=A[28]}
N 790 -7740 790 -3180 {
lab=A[30]}
N 1320 -7740 1320 -3180 {
lab=A[17]}
N 1240 -7740 1240 -3180 {
lab=A[19]}
N 1160 -7740 1160 -3180 {
lab=A[21]}
N 1080 -7740 1080 -3180 {
lab=A[23]}
N 1000 -7740 1000 -3180 {
lab=A[25]}
N 920 -7740 920 -3180 {
lab=A[27]}
N 840 -7740 840 -3180 {
lab=A[29]}
N 750 -7740 750 -3180 {
lab=A[31]}
N 1400 -7740 1400 -3180 {
lab=A[15]}
N 1480 -7740 1480 -3180 {
lab=A[13]}
N 1560 -7740 1560 -3180 {
lab=A[11]}
N 1640 -7740 1640 -3180 {
lab=A[9]}
N 1720 -7740 1720 -3180 {
lab=A[7]}
N 1800 -7740 1800 -3180 {
lab=A[5]}
N 1880 -7740 1880 -3180 {
lab=A[3]}
N 1960 -7740 1960 -3180 {
lab=A[1]}
N 1920 -7150 2310 -7150 {
lab=A[2]}
N 1880 -7010 2310 -7010 {
lab=A[3]}
N 2850 -3210 2900 -3210 {
lab=S0}
N 2850 -3060 2900 -3060 {
lab=S0}
N 2800 -3040 2900 -3040 {
lab=S1}
N 2800 -3200 2800 -3040 {
lab=S1}
N 2850 -3190 2850 -3060 {
lab=S0}
N 1960 -7570 2310 -7570 {
lab=A[1]}
N 1960 -7300 2350 -7300 {
lab=A[1]}
N 1840 -6840 2310 -6840 {
lab=A[4]}
N 2000 -7450 2390 -7450 {
lab=A[0]}
N 1800 -6990 2310 -6990 {
lab=A[5]}
N 1920 -7430 2350 -7430 {
lab=A[2]}
N 1880 -7280 2350 -7280 {
lab=A[3]}
N 1840 -7130 2350 -7130 {
lab=A[4]}
N 1760 -6820 2310 -6820 {
lab=A[6]}
N 740 -7750 2010 -7750 {
bus=true lab=A[31:0]}
N 3030 -7700 3090 -7700 {
lab=O[0]}
N 3030 -7550 3090 -7550 {
lab=O[1]}
N 3030 -7400 3090 -7400 {
lab=O[2]}
N 3030 -7250 3090 -7250 {
lab=O[3]}
N 3030 -7100 3090 -7100 {
lab=O[4]}
N 3030 -6950 3090 -6950 {
lab=O[5]}
N 3030 -6800 3090 -6800 {
lab=O[6]}
N 3030 -6650 3090 -6650 {
lab=O[7]}
N 3030 -6500 3090 -6500 {
lab=O[8]}
N 3030 -6350 3090 -6350 {
lab=O[9]}
N 3030 -6200 3090 -6200 {
lab=O[10]}
N 3030 -6050 3090 -6050 {
lab=O[11]}
N 3030 -5900 3090 -5900 {
lab=O[12]}
N 3030 -5750 3090 -5750 {
lab=O[13]}
N 3030 -5600 3090 -5600 {
lab=O[14]}
N 3030 -5440 3090 -5440 {
lab=O[15]}
N 3030 -5290 3090 -5290 {
lab=O[16]}
N 3030 -5140 3090 -5140 {
lab=O[17]}
N 3030 -4990 3090 -4990 {
lab=O[18]}
N 3030 -4840 3090 -4840 {
lab=O[19]}
N 3030 -4690 3090 -4690 {
lab=O[20]}
N 3030 -4540 3090 -4540 {
lab=O[21]}
N 3030 -4390 3090 -4390 {
lab=O[22]}
N 3030 -4240 3090 -4240 {
lab=O[23]}
N 3030 -4090 3090 -4090 {
lab=O[24]}
N 3030 -3940 3090 -3940 {
lab=O[25]}
N 3030 -3790 3090 -3790 {
lab=O[26]}
N 3030 -3640 3090 -3640 {
lab=O[27]}
N 3030 -3490 3090 -3490 {
lab=O[28]}
N 3030 -3340 3090 -3340 {
lab=O[29]}
N 3030 -3190 3090 -3190 {
lab=O[30]}
N 3030 -3040 3090 -3040 {
lab=O[31]}
N 2310 -7570 2460 -7570 {
lab=A[1]}
N 2390 -7450 2460 -7450 {
lab=A[0]}
N 2350 -7430 2460 -7430 {
lab=A[2]}
N 2350 -7300 2460 -7300 {
lab=A[1]}
N 2350 -7280 2460 -7280 {
lab=A[3]}
N 2350 -7130 2460 -7130 {
lab=A[4]}
N 2310 -7150 2460 -7150 {
lab=A[2]}
N 2310 -7010 2460 -7010 {
lab=A[3]}
N 2310 -6840 2460 -6840 {
lab=A[4]}
N 1800 -6690 2460 -6690 {
lab=A[5]}
N 1760 -6540 2460 -6540 {
lab=A[6]}
N 1720 -6390 2460 -6390 {
lab=A[7]}
N 1680 -6240 2460 -6240 {
lab=A[8]}
N 1640 -6100 2460 -6100 {
lab=A[9]}
N 1600 -5940 2460 -5940 {
lab=A[10]}
N 1560 -5800 2460 -5800 {
lab=A[11]}
N 1520 -5650 2460 -5650 {
lab=A[12]}
N 1480 -5490 2460 -5490 {
lab=A[13]}
N 1440 -5330 2460 -5330 {
lab=A[14]}
N 1400 -5180 2460 -5180 {
lab=A[15]}
N 1360 -5030 2460 -5030 {
lab=A[16]}
N 1320 -4880 2460 -4880 {
lab=A[17]}
N 1280 -4730 2460 -4730 {
lab=A[18]}
N 1240 -4580 2460 -4580 {
lab=A[19]}
N 1200 -4430 2460 -4430 {
lab=A[20]}
N 1160 -4280 2460 -4280 {
lab=A[21]}
N 1120 -4130 2460 -4130 {
lab=A[22]}
N 1080 -3980 2460 -3980 {
lab=A[23]}
N 1040 -3820 2460 -3820 {
lab=A[24]}
N 1000 -3680 2460 -3680 {
lab=A[25]}
N 960 -3540 2460 -3540 {
lab=A[26]}
N 920 -3380 2460 -3380 {
lab=A[27]}
N 880 -3230 2460 -3230 {
lab=A[28]}
N 840 -3080 2460 -3080 {
lab=A[29]}
N 790 -2940 2460 -2940 {
lab=A[30]}
N 2310 -6990 2460 -6990 {
lab=A[5]}
N 2310 -6820 2450 -6820 {
lab=A[6]}
N 2450 -6820 2460 -6820 {
lab=A[6]}
N 1720 -6670 2380 -6670 {
lab=A[7]}
N 1680 -6520 2380 -6520 {
lab=A[8]}
N 1640 -6370 2380 -6370 {
lab=A[9]}
N 1600 -6220 2380 -6220 {
lab=A[10]}
N 1560 -6080 2380 -6080 {
lab=A[11]}
N 1520 -5920 2380 -5920 {
lab=A[12]}
N 1480 -5780 2380 -5780 {
lab=A[13]}
N 1440 -5630 2380 -5630 {
lab=A[14]}
N 1400 -5470 2380 -5470 {
lab=A[15]}
N 1360 -5310 2380 -5310 {
lab=A[16]}
N 1320 -5160 2380 -5160 {
lab=A[17]}
N 1280 -5010 2380 -5010 {
lab=A[18]}
N 1240 -4860 2380 -4860 {
lab=A[19]}
N 1200 -4710 2380 -4710 {
lab=A[20]}
N 1160 -4560 2380 -4560 {
lab=A[21]}
N 1120 -4410 2380 -4410 {
lab=A[22]}
N 1080 -4260 2380 -4260 {
lab=A[23]}
N 1040 -4110 2380 -4110 {
lab=A[24]}
N 1000 -3960 2380 -3960 {
lab=A[25]}
N 960 -3800 2380 -3800 {
lab=A[26]}
N 920 -3660 2380 -3660 {
lab=A[27]}
N 880 -3520 2380 -3520 {
lab=A[28]}
N 840 -3360 2380 -3360 {
lab=A[29]}
N 800 -3210 2380 -3210 {
lab=A[30]}
N 760 -3060 2380 -3060 {
lab=A[31]}
N 2380 -6670 2460 -6670 {
lab=A[7]}
N 2380 -6520 2460 -6520 {
lab=A[8]}
N 2380 -6370 2460 -6370 {
lab=A[9]}
N 2380 -6220 2460 -6220 {
lab=A[10]}
N 2380 -6080 2460 -6080 {
lab=A[11]}
N 2380 -5920 2460 -5920 {
lab=A[12]}
N 2380 -5780 2460 -5780 {
lab=A[13]}
N 2380 -5630 2460 -5630 {
lab=A[14]}
N 2380 -5470 2460 -5470 {
lab=A[15]}
N 2380 -5310 2460 -5310 {
lab=A[16]}
N 2380 -5160 2460 -5160 {
lab=A[17]}
N 2380 -5010 2460 -5010 {
lab=A[18]}
N 2380 -4860 2460 -4860 {
lab=A[19]}
N 2380 -4710 2460 -4710 {
lab=A[20]}
N 2380 -4560 2460 -4560 {
lab=A[21]}
N 2380 -4410 2460 -4410 {
lab=A[22]}
N 2380 -4260 2460 -4260 {
lab=A[23]}
N 2380 -4110 2460 -4110 {
lab=A[24]}
N 2380 -3960 2460 -3960 {
lab=A[25]}
N 2380 -3800 2460 -3800 {
lab=A[26]}
N 2380 -3660 2460 -3660 {
lab=A[27]}
N 2380 -3520 2460 -3520 {
lab=A[28]}
N 2380 -2920 2460 -2920 {
lab=l}
N 2380 -3060 2460 -3060 {
lab=A[31]}
N 2380 -3210 2460 -3210 {
lab=A[30]}
N 2380 -3360 2460 -3360 {
lab=A[29]}
N 750 -4390 760 -4390 {
lab=A[31]}
N 790 -4490 800 -4490 {
lab=A[30]}
N 2000 -7670 2900 -7670 {
lab=A[0]}
N 1960 -7520 2900 -7520 {
lab=A[1]}
N 1920 -7370 2900 -7370 {
lab=A[2]}
N 1880 -7220 2900 -7220 {
lab=A[3]}
N 1840 -7070 2900 -7070 {
lab=A[4]}
N 1800 -6920 2900 -6920 {
lab=A[5]}
N 750 -3180 750 -2840 {
lab=A[31]}
N 790 -3180 790 -2840 {
lab=A[30]}
N 840 -3180 840 -2840 {
lab=A[29]}
N 880 -3180 880 -2840 {
lab=A[28]}
N 920 -3180 920 -2840 {
lab=A[27]}
N 960 -3180 960 -2840 {
lab=A[26]}
N 1000 -3180 1000 -2840 {
lab=A[25]}
N 1040 -3180 1040 -2840 {
lab=A[24]}
N 1080 -3180 1080 -2840 {
lab=A[23]}
N 1120 -3180 1120 -2840 {
lab=A[22]}
N 1160 -3180 1160 -2840 {
lab=A[21]}
N 1200 -3180 1200 -2840 {
lab=A[20]}
N 1240 -3180 1240 -2840 {
lab=A[19]}
N 1280 -3180 1280 -2840 {
lab=A[18]}
N 1320 -3180 1320 -2840 {
lab=A[17]}
N 1360 -3180 1360 -2840 {
lab=A[16]}
N 1400 -3180 1400 -2840 {
lab=A[15]}
N 1440 -3180 1440 -2840 {
lab=A[14]}
N 1480 -3180 1480 -2840 {
lab=A[13]}
N 1520 -3180 1520 -2840 {
lab=A[12]}
N 1560 -3180 1560 -2840 {
lab=A[11]}
N 1600 -3180 1600 -2840 {
lab=A[10]}
N 1640 -3180 1640 -2840 {
lab=A[9]}
N 1680 -3180 1680 -2840 {
lab=A[8]}
N 1720 -3180 1720 -2840 {
lab=A[7]}
N 1760 -3180 1760 -2840 {
lab=A[6]}
N 1800 -3180 1800 -2840 {
lab=A[5]}
N 1840 -3180 1840 -2840 {
lab=A[4]}
N 1880 -3180 1880 -2840 {
lab=A[3]}
N 1920 -3180 1920 -2840 {
lab=A[2]}
N 1960 -3180 1960 -2840 {
lab=A[1]}
N 2000 -3180 2000 -2840 {
lab=A[0]}
N 750 -3010 2900 -3010 {
lab=A[31]}
N 790 -3160 2900 -3160 {
lab=A[30]}
N 840 -3310 2900 -3310 {
lab=A[29]}
N 880 -3460 2900 -3460 {
lab=A[28]}
N 920 -3610 2900 -3610 {
lab=A[27]}
N 960 -3760 2900 -3760 {
lab=A[26]}
N 1010 -3910 2900 -3910 {
lab=A[25]}
N 1000 -3910 1010 -3910 {
lab=A[25]}
N 1040 -4060 2900 -4060 {
lab=A[24]}
N 1080 -4210 2900 -4210 {
lab=A[23]}
N 1120 -4360 2900 -4360 {
lab=A[22]}
N 1160 -4510 2900 -4510 {
lab=A[21]}
N 1200 -4660 2900 -4660 {
lab=A[20]}
N 1280 -4960 2900 -4960 {
lab=A[18]}
N 1240 -4810 2900 -4810 {
lab=A[19]}
N 1320 -5110 2900 -5110 {
lab=A[17]}
N 1360 -5260 2900 -5260 {
lab=A[16]}
N 1400 -5410 2900 -5410 {
lab=A[15]}
N 1440 -5570 2900 -5570 {
lab=A[14]}
N 1480 -5720 2900 -5720 {
lab=A[13]}
N 1530 -5870 2900 -5870 {
lab=A[12]}
N 1520 -5870 1530 -5870 {
lab=A[12]}
N 1560 -6020 2900 -6020 {
lab=A[11]}
N 1600 -6170 2900 -6170 {
lab=A[10]}
N 1640 -6320 2900 -6320 {
lab=A[9]}
N 1680 -6470 2900 -6470 {
lab=A[8]}
N 1720 -6620 2900 -6620 {
lab=A[7]}
N 1760 -6770 2900 -6770 {
lab=A[6]}
N 2590 -7500 2590 -7480 {
lab=Y1}
N 2590 -7350 2590 -7330 {
lab=Y2}
N 2590 -6900 2900 -6900 {
lab=#net1}
N 2590 -6750 2900 -6750 {
lab=#net2}
N 2590 -6600 2900 -6600 {
lab=#net3}
N 2590 -6450 2900 -6450 {
lab=#net4}
N 2590 -6150 2900 -6150 {
lab=#net5}
N 2590 -6000 2900 -6000 {
lab=#net6}
N 2590 -5850 2900 -5850 {
lab=#net7}
N 2590 -5700 2900 -5700 {
lab=#net8}
N 2590 -5550 2900 -5550 {
lab=#net9}
N 2590 -5390 2900 -5390 {
lab=#net10}
N 2590 -5240 2900 -5240 {
lab=#net11}
N 2590 -5090 2900 -5090 {
lab=#net12}
N 2590 -4940 2900 -4940 {
lab=#net13}
N 2590 -4790 2900 -4790 {
lab=#net14}
N 2590 -4640 2900 -4640 {
lab=#net15}
N 2590 -4490 2900 -4490 {
lab=#net16}
N 2590 -4340 2900 -4340 {
lab=#net17}
N 2590 -4190 2900 -4190 {
lab=#net18}
N 2590 -4040 2900 -4040 {
lab=#net19}
N 2590 -3890 2900 -3890 {
lab=#net20}
N 2590 -3740 2900 -3740 {
lab=#net21}
N 2590 -3590 2900 -3590 {
lab=#net22}
N 2590 -3440 2900 -3440 {
lab=#net23}
N 2590 -3290 2900 -3290 {
lab=#net24}
N 2590 -3140 2900 -3140 {
lab=#net25}
N 2590 -2990 2900 -2990 {
lab=#net26}
N 2590 -2990 2590 -2970 {
lab=#net26}
N 2590 -3140 2590 -3110 {
lab=#net25}
N 2590 -3290 2590 -3260 {
lab=#net24}
N 2590 -3440 2590 -3410 {
lab=#net23}
N 2590 -3590 2590 -3570 {
lab=#net22}
N 2590 -3740 2590 -3710 {
lab=#net21}
N 2590 -3890 2590 -3850 {
lab=#net20}
N 2590 -4040 2590 -4010 {
lab=#net19}
N 2590 -4190 2590 -4160 {
lab=#net18}
N 2590 -4340 2590 -4310 {
lab=#net17}
N 2590 -4490 2590 -4460 {
lab=#net16}
N 2590 -4640 2590 -4610 {
lab=#net15}
N 2590 -4790 2590 -4760 {
lab=#net14}
N 2590 -4940 2590 -4910 {
lab=#net13}
N 2590 -5090 2590 -5060 {
lab=#net12}
N 2590 -5240 2590 -5210 {
lab=#net11}
N 2590 -5390 2590 -5360 {
lab=#net10}
N 2590 -5550 2590 -5520 {
lab=#net9}
N 2590 -5700 2590 -5680 {
lab=#net8}
N 2590 -5850 2590 -5830 {
lab=#net7}
N 2590 -6000 2590 -5970 {
lab=#net6}
N 2590 -6150 2590 -6130 {
lab=#net5}
N 2590 -6300 2590 -6270 {
lab=#net27}
N 2590 -6450 2590 -6420 {
lab=#net4}
N 2590 -6600 2590 -6570 {
lab=#net3}
N 2590 -6750 2590 -6720 {
lab=#net2}
N 2590 -6900 2590 -6870 {
lab=#net1}
N 2590 -7200 2590 -7180 {
lab=Y3}
N 2600 -7630 2600 -7500 {
lab=Y1}
N 2600 -7030 2900 -7030 {
lab=#net1}
N 2600 -6880 2900 -6880 {
lab=#net2}
N 2600 -6730 2900 -6730 {
lab=#net3}
N 2600 -6580 2900 -6580 {
lab=#net4}
N 2600 -6430 2900 -6430 {
lab=#net27}
N 2600 -6130 2900 -6130 {
lab=#net6}
N 2600 -5980 2900 -5980 {
lab=#net7}
N 2600 -5830 2900 -5830 {
lab=#net8}
N 2600 -5680 2900 -5680 {
lab=#net9}
N 2600 -5530 2900 -5530 {
lab=#net10}
N 2600 -5370 2900 -5370 {
lab=#net11}
N 2600 -5220 2900 -5220 {
lab=#net12}
N 2600 -5070 2900 -5070 {
lab=#net13}
N 2600 -4920 2900 -4920 {
lab=#net14}
N 2600 -4770 2900 -4770 {
lab=#net15}
N 2600 -4620 2900 -4620 {
lab=#net16}
N 2600 -4470 2900 -4470 {
lab=#net17}
N 2600 -4320 2900 -4320 {
lab=#net18}
N 2600 -4170 2900 -4170 {
lab=#net19}
N 2600 -4020 2900 -4020 {
lab=#net20}
N 2600 -3870 2900 -3870 {
lab=#net21}
N 2600 -3720 2900 -3720 {
lab=#net22}
N 2600 -3570 2900 -3570 {
lab=#net23}
N 2600 -3420 2900 -3420 {
lab=#net24}
N 2600 -3270 2900 -3270 {
lab=#net25}
N 2600 -3120 2900 -3120 {
lab=#net26}
N 2600 -3120 2600 -2990 {
lab=#net26}
N 2600 -3270 2600 -3140 {
lab=#net25}
N 2600 -3420 2600 -3290 {
lab=#net24}
N 2600 -3870 2600 -3740 {
lab=#net21}
N 2600 -3720 2600 -3590 {
lab=#net22}
N 2600 -3570 2600 -3440 {
lab=#net23}
N 2600 -4020 2600 -3890 {
lab=#net20}
N 2600 -4170 2600 -4040 {
lab=#net19}
N 2600 -4320 2600 -4190 {
lab=#net18}
N 2600 -4470 2600 -4340 {
lab=#net17}
N 2600 -4620 2600 -4490 {
lab=#net16}
N 2600 -4770 2600 -4640 {
lab=#net15}
N 2600 -4920 2600 -4790 {
lab=#net14}
N 2600 -5070 2600 -4940 {
lab=#net13}
N 2600 -5220 2600 -5090 {
lab=#net12}
N 2600 -5370 2600 -5240 {
lab=#net11}
N 2600 -5530 2600 -5390 {
lab=#net10}
N 2600 -5680 2600 -5550 {
lab=#net9}
N 2600 -5830 2600 -5700 {
lab=#net8}
N 2600 -5980 2600 -5850 {
lab=#net7}
N 2600 -6130 2600 -6010 {
lab=#net6}
N 2600 -6010 2600 -6000 {
lab=#net6}
N 2600 -6280 2600 -6150 {
lab=#net5}
N 2600 -6430 2600 -6300 {
lab=#net27}
N 2600 -6580 2600 -6450 {
lab=#net4}
N 2600 -6730 2600 -6600 {
lab=#net3}
N 2600 -6880 2600 -6750 {
lab=#net2}
N 2600 -7030 2600 -6900 {
lab=#net1}
N 2610 -7610 2610 -7350 {
lab=Y2}
N 2620 -7460 2620 -7200 {
lab=Y3}
N 2640 -7160 2900 -7160 {
lab=#net1}
N 2640 -7160 2640 -6900 {
lab=#net1}
N 2650 -7010 2900 -7010 {
lab=#net2}
N 2650 -7010 2650 -6750 {
lab=#net2}
N 2660 -6860 2900 -6860 {
lab=#net3}
N 2660 -6860 2660 -6600 {
lab=#net3}
N 2670 -6710 2900 -6710 {
lab=#net4}
N 2670 -6710 2670 -6450 {
lab=#net4}
N 2680 -6560 2900 -6560 {
lab=#net27}
N 2680 -6560 2680 -6300 {
lab=#net27}
N 2690 -6410 2900 -6410 {
lab=#net5}
N 2690 -6410 2690 -6150 {
lab=#net5}
N 2700 -6260 2700 -6000 {
lab=#net6}
N 2710 -6110 2900 -6110 {
lab=#net7}
N 2710 -6110 2710 -5850 {
lab=#net7}
N 2720 -5960 2900 -5960 {
lab=#net8}
N 2720 -5960 2720 -5700 {
lab=#net8}
N 2730 -5810 2900 -5810 {
lab=#net9}
N 2730 -5810 2730 -5550 {
lab=#net9}
N 2740 -5660 2900 -5660 {
lab=#net10}
N 2740 -5660 2740 -5390 {
lab=#net10}
N 2750 -5510 2900 -5510 {
lab=#net11}
N 2750 -5510 2750 -5240 {
lab=#net11}
N 2760 -5350 2900 -5350 {
lab=#net12}
N 2760 -5350 2760 -5090 {
lab=#net12}
N 2770 -5200 2900 -5200 {
lab=#net13}
N 2770 -5200 2770 -4940 {
lab=#net13}
N 2760 -5050 2900 -5050 {
lab=#net14}
N 2760 -5050 2760 -4790 {
lab=#net14}
N 2800 -7760 2800 -3190 {
lab=S1}
N 2750 -4900 2900 -4900 {
lab=#net15}
N 2750 -4900 2750 -4640 {
lab=#net15}
N 2740 -4750 2900 -4750 {
lab=#net16}
N 2740 -4750 2740 -4490 {
lab=#net16}
N 2730 -4600 2900 -4600 {
lab=#net17}
N 2730 -4600 2730 -4340 {
lab=#net17}
N 2720 -4450 2900 -4450 {
lab=#net18}
N 2720 -4450 2720 -4190 {
lab=#net18}
N 2710 -4300 2900 -4300 {
lab=#net19}
N 2710 -4300 2710 -4040 {
lab=#net19}
N 2700 -4150 2900 -4150 {
lab=#net20}
N 2700 -4150 2700 -3890 {
lab=#net20}
N 2690 -4000 2900 -4000 {
lab=#net21}
N 2690 -4000 2690 -3740 {
lab=#net21}
N 2680 -3850 2900 -3850 {
lab=#net22}
N 2680 -3850 2680 -3590 {
lab=#net22}
N 2670 -3700 2900 -3700 {
lab=#net23}
N 2670 -3700 2670 -3440 {
lab=#net23}
N 2660 -3550 2900 -3550 {
lab=#net24}
N 2660 -3550 2660 -3290 {
lab=#net24}
N 2650 -3400 2900 -3400 {
lab=#net25}
N 2650 -3400 2650 -3140 {
lab=#net25}
N 2640 -3250 2900 -3250 {
lab=#net26}
N 2640 -3250 2640 -2990 {
lab=#net26}
N 2380 -2920 2380 -2720 {
lab=l}
N 2420 -5280 2420 -2970 {
lab=S}
N 2420 -7580 2420 -5270 {
lab=S}
N 2420 -7710 2420 -7580 {
lab=S}
N 2440 -7590 2460 -7590 {
lab=l}
N 2440 -7700 2440 -7590 {
lab=l}
N 2420 -7620 2460 -7620 {
lab=S}
N 2420 -7480 2460 -7480 {
lab=S}
N 2420 -7330 2460 -7330 {
lab=S}
N 2420 -7180 2460 -7180 {
lab=S}
N 2420 -7040 2460 -7040 {
lab=S}
N 2420 -6870 2460 -6870 {
lab=S}
N 2420 -6720 2460 -6720 {
lab=S}
N 2420 -6570 2460 -6570 {
lab=S}
N 2420 -6420 2460 -6420 {
lab=S}
N 2420 -6270 2460 -6270 {
lab=S}
N 2420 -6130 2460 -6130 {
lab=S}
N 2420 -5970 2460 -5970 {
lab=S}
N 2420 -5830 2460 -5830 {
lab=S}
N 2420 -5680 2460 -5680 {
lab=S}
N 2420 -5520 2460 -5520 {
lab=S}
N 2420 -5360 2460 -5360 {
lab=S}
N 2420 -5210 2460 -5210 {
lab=S}
N 2420 -5060 2460 -5060 {
lab=S}
N 2420 -4910 2460 -4910 {
lab=S}
N 2420 -4760 2460 -4760 {
lab=S}
N 2420 -4610 2460 -4610 {
lab=S}
N 2420 -4460 2460 -4460 {
lab=S}
N 2420 -4310 2460 -4310 {
lab=S}
N 2420 -4160 2460 -4160 {
lab=S}
N 2420 -4010 2460 -4010 {
lab=S}
N 2420 -3850 2460 -3850 {
lab=S}
N 2420 -3710 2460 -3710 {
lab=S}
N 2420 -3570 2460 -3570 {
lab=S}
N 2420 -3410 2460 -3410 {
lab=S}
N 2420 -3260 2460 -3260 {
lab=S}
N 2420 -3110 2460 -3110 {
lab=S}
N 2420 -2970 2460 -2970 {
lab=S}
N 3090 -7700 3150 -7700 {
lab=O[0]}
N 3090 -7550 3150 -7550 {
lab=O[1]}
N 3090 -7400 3150 -7400 {
lab=O[2]}
N 3090 -7250 3150 -7250 {
lab=O[3]}
N 3090 -7100 3150 -7100 {
lab=O[4]}
N 3090 -6950 3150 -6950 {
lab=O[5]}
N 3090 -6800 3150 -6800 {
lab=O[6]}
N 3090 -6650 3150 -6650 {
lab=O[7]}
N 3090 -6500 3150 -6500 {
lab=O[8]}
N 3090 -6350 3150 -6350 {
lab=O[9]}
N 3090 -6200 3150 -6200 {
lab=O[10]}
N 3090 -6050 3150 -6050 {
lab=O[11]}
N 3090 -5900 3150 -5900 {
lab=O[12]}
N 3090 -5750 3150 -5750 {
lab=O[13]}
N 3090 -5600 3150 -5600 {
lab=O[14]}
N 3090 -5440 3150 -5440 {
lab=O[15]}
N 3090 -5290 3150 -5290 {
lab=O[16]}
N 3090 -5140 3150 -5140 {
lab=O[17]}
N 3090 -4990 3150 -4990 {
lab=O[18]}
N 3090 -4840 3150 -4840 {
lab=O[19]}
N 3090 -4690 3150 -4690 {
lab=O[20]}
N 3090 -4540 3150 -4540 {
lab=O[21]}
N 3090 -4390 3150 -4390 {
lab=O[22]}
N 3090 -4240 3150 -4240 {
lab=O[23]}
N 3090 -4090 3150 -4090 {
lab=O[24]}
N 3090 -3940 3150 -3940 {
lab=O[25]}
N 3090 -3790 3150 -3790 {
lab=O[26]}
N 3090 -3640 3150 -3640 {
lab=O[27]}
N 3090 -3490 3150 -3490 {
lab=O[28]}
N 3090 -3340 3150 -3340 {
lab=O[29]}
N 3090 -3190 3150 -3190 {
lab=O[30]}
N 3090 -3040 3150 -3040 {
lab=O[31]}
N 3160 -7730 3160 -2970 {
lab=O[31:0]
bus=true}
N 750 -3060 760 -3060 {
lab=A[31]}
N 790 -3210 800 -3210 {
lab=A[30]}
N 2780 -3100 2900 -3100 {
lab=l}
N 2780 -3100 2780 -2950 {
lab=l}
N 2780 -2950 2900 -2950 {
lab=l}
N 2780 -2950 2780 -2870 {
lab=l}
N 2780 -2970 2900 -2970 {
lab=l}
N 2870 -3190 2900 -3190 {
lab=S1}
N 2870 -3190 2870 -3180 {
lab=S1}
N 2800 -3180 2870 -3180 {
lab=S1}
N 2590 -7650 2590 -7620 {
lab=#net28}
N 2740 -7630 2900 -7630 {
lab=Y1O}
N 2590 -7650 2900 -7650 {
lab=#net28}
N 2850 -7750 2880 -7750 {
lab=S0}
N 2880 -7840 2880 -7810 {
lab=S0'}
N 2350 -8330 2370 -8330 {
lab=S0'}
N 2290 -8350 2370 -8350 {
lab=#net29}
N 2110 -8360 2150 -8360 {
lab=S}
N 2110 -8340 2150 -8340 {
lab=S1}
N 2350 -8310 2370 -8310 {
lab=Y1}
N 2475 -8330 2510 -8330 {
lab=Y1O}
N 2340 -8160 2360 -8160 {
lab=S0'}
N 2290 -8240 2370 -8240 {
lab=#net30}
N 2110 -8250 2150 -8250 {
lab=S0}
N 2110 -8230 2150 -8230 {
lab=S1}
N 2340 -8140 2360 -8140 {
lab=S}
N 2765 -8200 2800 -8200 {
lab=Y2O}
N 2740 -7610 2900 -7610 {
lab=Y2O}
N 2350 -8220 2370 -8220 {
lab=S'}
N 2370 -7780 2370 -7750 {
lab=S'}
N 2370 -7690 2420 -7690 {
lab=S}
N 2770 -7720 2800 -7720 {
lab=S1}
N 2770 -7810 2770 -7780 {
lab=S1'}
N 2340 -8180 2360 -8180 {
lab=S1'}
N 2450 -8230 2510 -8230 {
lab=#net31}
N 2510 -8230 2510 -8220 {
lab=#net31}
N 2510 -8220 2530 -8220 {
lab=#net31}
N 2470 -8160 2510 -8160 {
lab=#net32}
N 2510 -8200 2510 -8160 {
lab=#net32}
N 2510 -8200 2530 -8200 {
lab=#net32}
N 2660 -8210 2690 -8210 {
lab=#net33}
N 2660 -8190 2690 -8190 {
lab=Y2}
N 2340 -8010 2360 -8010 {
lab=S0'}
N 2290 -8090 2370 -8090 {
lab=#net34}
N 2110 -8100 2150 -8100 {
lab=S0}
N 2110 -8080 2150 -8080 {
lab=S1}
N 2340 -7990 2360 -7990 {
lab=S}
N 2765 -8050 2800 -8050 {
lab=Y3O}
N 2350 -8070 2370 -8070 {
lab=S'}
N 2340 -8030 2360 -8030 {
lab=S1'}
N 2450 -8080 2510 -8080 {
lab=#net35}
N 2510 -8080 2510 -8070 {
lab=#net35}
N 2510 -8070 2530 -8070 {
lab=#net35}
N 2470 -8010 2510 -8010 {
lab=#net36}
N 2510 -8050 2510 -8010 {
lab=#net36}
N 2510 -8050 2530 -8050 {
lab=#net36}
N 2660 -8060 2690 -8060 {
lab=#net37}
N 2660 -8040 2690 -8040 {
lab=Y3}
N 2740 -7460 2900 -7460 {
lab=Y3O}
N 2460 -8160 2470 -8160 {
lab=#net32}
N 2460 -8010 2470 -8010 {
lab=#net36}
N 2630 -7310 2900 -7310 {
lab=#net38}
N 2630 -7310 2630 -7050 {
lab=#net38}
N 2590 -7050 2590 -7040 {
lab=#net38}
N 2590 -7050 2900 -7050 {
lab=#net38}
N 2600 -7180 2600 -7050 {
lab=#net38}
N 2600 -7180 2900 -7180 {
lab=#net38}
N 2740 -7330 2900 -7330 {
lab=Y3O}
N 2740 -7200 2900 -7200 {
lab=Y3O}
N 2590 -7200 2620 -7200 {
lab=Y3}
N 2740 -7480 2900 -7480 {
lab=Y2O}
N 2740 -7350 2900 -7350 {
lab=Y2O}
N 2590 -7350 2610 -7350 {
lab=Y2}
N 2740 -7500 2900 -7500 {
lab=Y1O}
N 2590 -7500 2600 -7500 {
lab=Y1}
N 2700 -6260 2900 -6260 {
lab=#net6}
N 2600 -6280 2900 -6280 {
lab=#net5}
N 2590 -6300 2900 -6300 {
lab=#net27}
C {4x1_mux.sym} 2970 -7640 0 0 {name=x1}
C {4x1_mux.sym} 2970 -7490 0 0 {name=x2}
C {4x1_mux.sym} 2970 -7340 0 0 {name=x3}
C {4x1_mux.sym} 2970 -7190 0 0 {name=x4}
C {4x1_mux.sym} 2970 -7040 0 0 {name=x5}
C {4x1_mux.sym} 2970 -6890 0 0 {name=x6}
C {4x1_mux.sym} 2970 -6740 0 0 {name=x7}
C {4x1_mux.sym} 2970 -6590 0 0 {name=x8}
C {4x1_mux.sym} 2970 -6440 0 0 {name=x9}
C {4x1_mux.sym} 2970 -6290 0 0 {name=x10}
C {4x1_mux.sym} 2970 -6140 0 0 {name=x11}
C {4x1_mux.sym} 2970 -5990 0 0 {name=x12}
C {4x1_mux.sym} 2970 -5840 0 0 {name=x13}
C {4x1_mux.sym} 2970 -5690 0 0 {name=x14}
C {4x1_mux.sym} 2970 -5540 0 0 {name=x15}
C {4x1_mux.sym} 2970 -5380 0 0 {name=x16}
C {4x1_mux.sym} 2970 -5230 0 0 {name=x17}
C {4x1_mux.sym} 2970 -5080 0 0 {name=x18}
C {4x1_mux.sym} 2970 -4930 0 0 {name=x19}
C {4x1_mux.sym} 2970 -4780 0 0 {name=x20}
C {4x1_mux.sym} 2970 -4630 0 0 {name=x21}
C {4x1_mux.sym} 2970 -4480 0 0 {name=x22}
C {4x1_mux.sym} 2970 -4330 0 0 {name=x23}
C {4x1_mux.sym} 2970 -4180 0 0 {name=x24}
C {4x1_mux.sym} 2970 -4030 0 0 {name=x25}
C {4x1_mux.sym} 2970 -3880 0 0 {name=x26}
C {4x1_mux.sym} 2970 -3730 0 0 {name=x27}
C {4x1_mux.sym} 2970 -3580 0 0 {name=x28}
C {4x1_mux.sym} 2970 -3430 0 0 {name=x29}
C {4x1_mux.sym} 2970 -3280 0 0 {name=x30}
C {devices/bus_tap.sym} 1990 -7750 1 0 {name=l1 lab=[0]}
C {devices/bus_tap.sym} 1950 -7750 1 0 {name=l2 lab=[1]}
C {devices/bus_tap.sym} 1910 -7750 1 0 {name=l3 lab=[2]}
C {devices/bus_tap.sym} 1870 -7750 1 0 {name=l4 lab=[3]}
C {devices/bus_tap.sym} 1830 -7750 1 0 {name=l5 lab=[4]}
C {devices/bus_tap.sym} 1790 -7750 1 0 {name=l6 lab=[5]}
C {devices/bus_tap.sym} 1750 -7750 1 0 {name=l7 lab=[6]}
C {devices/bus_tap.sym} 1710 -7750 1 0 {name=l8 lab=[7]}
C {devices/bus_tap.sym} 1670 -7750 1 0 {name=l9 lab=[8]}
C {devices/bus_tap.sym} 1630 -7750 1 0 {name=l10 lab=[9]}
C {devices/bus_tap.sym} 1590 -7750 1 0 {name=l11 lab=[10]}
C {devices/bus_tap.sym} 1550 -7750 1 0 {name=l12 lab=[11]}
C {devices/bus_tap.sym} 1510 -7750 1 0 {name=l13 lab=[12]}
C {devices/bus_tap.sym} 1470 -7750 1 0 {name=l14 lab=[13]}
C {devices/bus_tap.sym} 1430 -7750 1 0 {name=l15 lab=[14]}
C {devices/bus_tap.sym} 1390 -7750 1 0 {name=l16 lab=[15]}
C {devices/bus_tap.sym} 1350 -7750 1 0 {name=l17 lab=[16]}
C {devices/bus_tap.sym} 1310 -7750 1 0 {name=l18 lab=[17]}
C {devices/bus_tap.sym} 1270 -7750 1 0 {name=l19 lab=[18]}
C {devices/bus_tap.sym} 1230 -7750 1 0 {name=l20 lab=[19]}
C {devices/bus_tap.sym} 1190 -7750 1 0 {name=l21 lab=[20]}
C {devices/bus_tap.sym} 1150 -7750 1 0 {name=l23 lab=[21]}
C {devices/bus_tap.sym} 1110 -7750 1 0 {name=l24 lab=[22]}
C {devices/bus_tap.sym} 1070 -7750 1 0 {name=l25 lab=[23]}
C {devices/bus_tap.sym} 1030 -7750 1 0 {name=l26 lab=[24]}
C {devices/bus_tap.sym} 990 -7750 1 0 {name=l27 lab=[25]}
C {devices/bus_tap.sym} 950 -7750 1 0 {name=l28 lab=[26]}
C {devices/bus_tap.sym} 910 -7750 1 0 {name=l29 lab=[27]}
C {devices/bus_tap.sym} 870 -7750 1 0 {name=l30 lab=[28]}
C {devices/bus_tap.sym} 830 -7750 1 0 {name=l31 lab=[29]}
C {devices/bus_tap.sym} 780 -7750 1 0 {name=l22 lab=[30]}
C {devices/bus_tap.sym} 740 -7750 1 0 {name=l32 lab=[31]}
C {4x1_mux.sym} 2970 -3130 0 0 {name=x31}
C {4x1_mux.sym} 2970 -2980 0 0 {name=x32}
C {2x1_mux.sym} 2520 -7590 0 0 {name=x67}
C {2x1_mux.sym} 2520 -7450 0 0 {name=x68}
C {2x1_mux.sym} 2520 -7300 0 0 {name=x69}
C {2x1_mux.sym} 2520 -7150 0 0 {name=x70}
C {2x1_mux.sym} 2520 -7010 0 0 {name=x71}
C {2x1_mux.sym} 2520 -6840 0 0 {name=x72}
C {2x1_mux.sym} 2520 -6690 0 0 {name=x73}
C {2x1_mux.sym} 2520 -6540 0 0 {name=x74}
C {2x1_mux.sym} 2520 -6390 0 0 {name=x75}
C {2x1_mux.sym} 2520 -6240 0 0 {name=x76}
C {2x1_mux.sym} 2520 -6100 0 0 {name=x77}
C {2x1_mux.sym} 2520 -5940 0 0 {name=x78}
C {2x1_mux.sym} 2520 -5800 0 0 {name=x79}
C {2x1_mux.sym} 2520 -5650 0 0 {name=x80}
C {2x1_mux.sym} 2520 -5490 0 0 {name=x81}
C {2x1_mux.sym} 2520 -5330 0 0 {name=x82}
C {2x1_mux.sym} 2520 -5180 0 0 {name=x83}
C {2x1_mux.sym} 2520 -5030 0 0 {name=x84}
C {2x1_mux.sym} 2520 -4880 0 0 {name=x85}
C {2x1_mux.sym} 2520 -4730 0 0 {name=x86}
C {2x1_mux.sym} 2520 -4580 0 0 {name=x87}
C {2x1_mux.sym} 2520 -4430 0 0 {name=x88}
C {2x1_mux.sym} 2520 -4280 0 0 {name=x89}
C {2x1_mux.sym} 2520 -4130 0 0 {name=x90}
C {2x1_mux.sym} 2520 -3980 0 0 {name=x91}
C {2x1_mux.sym} 2520 -3820 0 0 {name=x92}
C {2x1_mux.sym} 2520 -3680 0 0 {name=x93}
C {2x1_mux.sym} 2520 -3540 0 0 {name=x94}
C {2x1_mux.sym} 2520 -3380 0 0 {name=x95}
C {2x1_mux.sym} 2520 -3230 0 0 {name=x96}
C {2x1_mux.sym} 2520 -3080 0 0 {name=x97}
C {2x1_mux.sym} 2520 -2940 0 0 {name=x98}
C {devices/vsource.sym} 5570 -5340 0 0 {name=VB1 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 5570 -5370 0 0 {name=VB2 sig_type=std_logic lab=A[3]}
C {devices/gnd.sym} 5570 -5310 0 0 {name=l34 lab=GND}
C {devices/vsource.sym} 5010 -5330 0 0 {name=VB3 value="pwl=0 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 5010 -5360 0 0 {name=VB4 sig_type=std_logic lab=A[1]}
C {devices/gnd.sym} 5010 -5300 0 0 {name=l36 lab=GND}
C {devices/vsource.sym} 4800 -5350 0 0 {name=VB5 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 4800 -5380 0 0 {name=VB6 sig_type=std_logic lab=A[0]}
C {devices/gnd.sym} 4800 -5320 0 0 {name=l38 lab=GND}
C {devices/vsource.sym} 5250 -5350 0 0 {name=VB7 value="pwl=0 1.8 100n 1.8 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 5250 -5380 0 0 {name=VB8 sig_type=std_logic lab=A[2]}
C {devices/gnd.sym} 5250 -5320 0 0 {name=l40 lab=GND}
C {devices/vsource.sym} 5570 -5540 0 0 {name=VB9 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 5570 -5570 0 0 {name=VB10 sig_type=std_logic lab=A[7]}
C {devices/gnd.sym} 5570 -5510 0 0 {name=l42 lab=GND}
C {devices/vsource.sym} 5010 -5530 0 0 {name=VB11 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 5010 -5560 0 0 {name=VB12 sig_type=std_logic lab=A[5]}
C {devices/gnd.sym} 5010 -5500 0 0 {name=l44 lab=GND}
C {devices/vsource.sym} 4840 -5550 0 0 {name=VB13 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 4840 -5580 0 0 {name=VB14 sig_type=std_logic lab=A[4]}
C {devices/gnd.sym} 4840 -5520 0 0 {name=l46 lab=GND}
C {devices/vsource.sym} 5250 -5550 0 0 {name=VB15 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 5250 -5580 0 0 {name=VB16 sig_type=std_logic lab=A[6]}
C {devices/gnd.sym} 5250 -5520 0 0 {name=l48 lab=GND}
C {devices/vsource.sym} 5570 -5740 0 0 {name=VB17 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 5570 -5770 0 0 {name=VB18 sig_type=std_logic lab=A[13]}
C {devices/gnd.sym} 5570 -5710 0 0 {name=l50 lab=GND}
C {devices/vsource.sym} 5010 -5730 0 0 {name=VB19 value="pwl=0 1.8 100n 1.8 " savecurrent=false}
C {devices/lab_pin.sym} 5010 -5760 0 0 {name=VB20 sig_type=std_logic lab=A[11]}
C {devices/gnd.sym} 5010 -5700 0 0 {name=l52 lab=GND}
C {devices/vsource.sym} 4840 -5750 0 0 {name=VB21 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 4840 -5780 0 0 {name=VB22 sig_type=std_logic lab=A[10]}
C {devices/gnd.sym} 4840 -5720 0 0 {name=l54 lab=GND}
C {devices/vsource.sym} 5250 -5750 0 0 {name=VB23 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 5250 -5780 0 0 {name=VB24 sig_type=std_logic lab=A[12]}
C {devices/gnd.sym} 5250 -5720 0 0 {name=l56 lab=GND}
C {devices/vsource.sym} 5570 -5940 0 0 {name=VB25 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 5570 -5970 0 0 {name=VB26 sig_type=std_logic lab=A[9]}
C {devices/gnd.sym} 5570 -5910 0 0 {name=l58 lab=GND}
C {devices/vsource.sym} 5010 -5930 0 0 {name=VB27 value="pwl=0 0 100n 0 " savecurrent=false}
C {devices/lab_pin.sym} 5010 -5960 0 0 {name=VB28 sig_type=std_logic lab=A[15]}
C {devices/gnd.sym} 5010 -5900 0 0 {name=l60 lab=GND}
C {devices/vsource.sym} 4840 -5950 0 0 {name=VB29 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 4840 -5980 0 0 {name=VB30 sig_type=std_logic lab=A[14]}
C {devices/gnd.sym} 4840 -5920 0 0 {name=l62 lab=GND}
C {devices/vsource.sym} 5250 -5950 0 0 {name=VB31 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 5250 -5980 0 0 {name=VB32 sig_type=std_logic lab=A[8]}
C {devices/gnd.sym} 5250 -5920 0 0 {name=l64 lab=GND}
C {devices/vsource.sym} 5050 -6390 0 0 {name=VA19 value="pwl=0 0 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 5050 -6420 0 0 {name=p22 sig_type=std_logic lab=A[23]}
C {devices/vsource.sym} 5050 -6290 0 0 {name=VA20 value="pwl=0 1.8 50n 1.8 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 5050 -6320 0 0 {name=p23 sig_type=std_logic lab=A[22]}
C {devices/vsource.sym} 5050 -6190 0 0 {name=VA21 value="pwl=0 1.8 50n 1.8 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 5050 -6220 0 0 {name=p24 sig_type=std_logic lab=A[21]}
C {devices/vsource.sym} 5050 -6090 0 0 {name=VA22 value="pwl=0 1.8 50n 1.8 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 5050 -6120 0 0 {name=VA23 sig_type=std_logic lab=A[20]}
C {devices/gnd.sym} 5050 -6060 0 0 {name=l91 lab=GND}
C {devices/gnd.sym} 5050 -6160 0 0 {name=l93 lab=GND}
C {devices/gnd.sym} 5050 -6260 0 0 {name=l95 lab=GND}
C {devices/gnd.sym} 5050 -6360 0 0 {name=l98 lab=GND}
C {devices/vsource.sym} 5470 -6360 0 0 {name=VA24 value="pwl=0 0 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 5470 -6390 0 0 {name=p25 sig_type=std_logic lab=A[17]}
C {devices/vsource.sym} 5470 -6260 0 0 {name=VA25 value="pwl=0 1.8 50n 1.8 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 5470 -6290 0 0 {name=p26 sig_type=std_logic lab=A[16]}
C {devices/gnd.sym} 5470 -6230 0 0 {name=l103 lab=GND}
C {devices/gnd.sym} 5470 -6330 0 0 {name=l106 lab=GND}
C {devices/vsource.sym} 5051.46728515625 -6508.88671875 0 0 {name=VA29 value="pwl=0 1.8 50n 1.8 50n 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 5051.46728515625 -6538.88671875 0 0 {name=p28 sig_type=std_logic lab=A[28]}
C {devices/gnd.sym} 5051.46728515625 -6478.88671875 0 0 {name=l107 lab=GND}
C {devices/vsource.sym} 5471.46728515625 -6488.88671875 0 0 {name=VA30 value="pwl=0 1.8 50n 1.8 50n 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 5471.46728515625 -6518.88671875 0 0 {name=p29 sig_type=std_logic lab=A[18]}
C {devices/gnd.sym} 5471.46728515625 -6458.88671875 0 0 {name=l108 lab=GND}
C {devices/vsource.sym} 5051.46728515625 -6658.88671875 0 0 {name=VA31 value="pwl=0 1.8 50n 1.8 50n 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 5051.46728515625 -6688.88671875 0 0 {name=p30 sig_type=std_logic lab=A[29]}
C {devices/gnd.sym} 5051.46728515625 -6628.88671875 0 0 {name=l109 lab=GND}
C {devices/vsource.sym} 5461.46728515625 -6628.88671875 0 0 {name=VA32 value="pwl=0 1.8 50n 1.8 50n 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 5461.46728515625 -6658.88671875 0 0 {name=p31 sig_type=std_logic lab=A[30]}
C {devices/gnd.sym} 5461.46728515625 -6598.88671875 0 0 {name=l110 lab=GND}
C {devices/vsource.sym} 5241.46728515625 -6168.88671875 0 0 {name=VA38 value="pwl=0 1.8 50n 1.8 50n 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 5241.46728515625 -6198.88671875 0 0 {name=p36 sig_type=std_logic lab=A[19]}
C {devices/gnd.sym} 5241.46728515625 -6138.88671875 0 0 {name=l117 lab=GND}
C {devices/vsource.sym} 5770 -6450 0 0 {name=VA39 value="pwl=0 0 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 5770 -6480 0 0 {name=p37 sig_type=std_logic lab=A[27]}
C {devices/vsource.sym} 5770 -6350 0 0 {name=VA40 value="pwl=0 1.8 50n 1.8 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 5770 -6380 0 0 {name=p38 sig_type=std_logic lab=A[26]}
C {devices/vsource.sym} 5770 -6250 0 0 {name=VA41 value="pwl=0 1.8 50n 1.8 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 5770 -6280 0 0 {name=p39 sig_type=std_logic lab=A[25]}
C {devices/vsource.sym} 5770 -6150 0 0 {name=VA42 value="pwl=0 1.8 50n 1.8 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 5770 -6180 0 0 {name=VA43 sig_type=std_logic lab=A[24]}
C {devices/gnd.sym} 5770 -6120 0 0 {name=l118 lab=GND}
C {devices/gnd.sym} 5770 -6220 0 0 {name=l119 lab=GND}
C {devices/gnd.sym} 5770 -6320 0 0 {name=l120 lab=GND}
C {devices/gnd.sym} 5770 -6420 0 0 {name=l121 lab=GND}
C {devices/vsource.sym} 5731.46728515625 -6548.88671875 0 0 {name=VA44 value="pwl=0 1.8 50n 1.8 50n 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 5731.46728515625 -6578.88671875 0 0 {name=p40 sig_type=std_logic lab=A[31]}
C {devices/gnd.sym} 5731.46728515625 -6518.88671875 0 0 {name=l122 lab=GND}
C {devices/vsource.sym} 6301.46728515625 -5338.88671875 0 0 {name=VDD value=1.8 savecurrent=false}
C {devices/lab_pin.sym} 6301.46728515625 -5368.88671875 0 0 {name=VDD1 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 6301.46728515625 -5308.88671875 0 0 {name=VDD2 lab=GND}
C {devices/code_shown.sym} 6390 -5465 0 0 {name=S1 only_toplevel=false value=".tran 0.01n 300n
.save all"}
C {sky130_fd_pr/corner.sym} 6375 -5395 0 0 {name=CORNER only_toplevel=true corner=tt}
C {devices/ipin.sym} 740 -7750 0 0 {name=p16 sig_type=std_logic lab=A[31:0]}
C {devices/bus_tap.sym} 3160 -7690 0 1 {name=l193 lab=[0]}
C {devices/bus_tap.sym} 3160 -7540 0 1 {name=l194 lab=[1]}
C {devices/bus_tap.sym} 3160 -7390 0 1 {name=l195 lab=[2]}
C {devices/bus_tap.sym} 3160 -7240 0 1 {name=l196 lab=[3]}
C {devices/bus_tap.sym} 3160 -7090 0 1 {name=l197 lab=[4]}
C {devices/bus_tap.sym} 3160 -6940 0 1 {name=l198 lab=[5]}
C {devices/bus_tap.sym} 3160 -6790 0 1 {name=l199 lab=[6]}
C {devices/bus_tap.sym} 3160 -6640 0 1 {name=l200 lab=[7]}
C {devices/bus_tap.sym} 3160 -6490 0 1 {name=l201 lab=[8]}
C {devices/bus_tap.sym} 3160 -6340 0 1 {name=l202 lab=[9]}
C {devices/bus_tap.sym} 3160 -6190 0 1 {name=l203 lab=[10]}
C {devices/bus_tap.sym} 3160 -6040 0 1 {name=l204 lab=[11]}
C {devices/bus_tap.sym} 3160 -5890 0 1 {name=l205 lab=[12]}
C {devices/bus_tap.sym} 3160 -5740 0 1 {name=l206 lab=[13]}
C {devices/bus_tap.sym} 3160 -5590 0 1 {name=l207 lab=[14]}
C {devices/bus_tap.sym} 3160 -5430 0 1 {name=l208 lab=[15]}
C {devices/bus_tap.sym} 3160 -5280 0 1 {name=l209 lab=[16]}
C {devices/bus_tap.sym} 3160 -5130 0 1 {name=l210 lab=[17]}
C {devices/bus_tap.sym} 3160 -4980 0 1 {name=l211 lab=[18]}
C {devices/bus_tap.sym} 3160 -4830 0 1 {name=l212 lab=[19]}
C {devices/bus_tap.sym} 3160 -4680 0 1 {name=l213 lab=[20]}
C {devices/bus_tap.sym} 3160 -4530 0 1 {name=l214 lab=[21]}
C {devices/bus_tap.sym} 3160 -4380 0 1 {name=l215 lab=[22]}
C {devices/bus_tap.sym} 3160 -4230 0 1 {name=l216 lab=[23]}
C {devices/bus_tap.sym} 3160 -4080 0 1 {name=l217 lab=[24]}
C {devices/bus_tap.sym} 3160 -3930 0 1 {name=l218 lab=[25]}
C {devices/bus_tap.sym} 3160 -3780 0 1 {name=l219 lab=[26]}
C {devices/bus_tap.sym} 3160 -3630 0 1 {name=l220 lab=[27]}
C {devices/bus_tap.sym} 3160 -3480 0 1 {name=l221 lab=[28]}
C {devices/bus_tap.sym} 3160 -3330 0 1 {name=l222 lab=[29]}
C {devices/bus_tap.sym} 3160 -3180 0 1 {name=l223 lab=[30]}
C {devices/bus_tap.sym} 3160 -3030 0 1 {name=l224 lab=[31]}
C {devices/opin.sym} 3160 -7730 1 0 {name=p1 sig_type=std_logic lab=O[31:0]}
C {devices/ipin.sym} 2850 -7760 1 0 {name=p2 sig_type=std_logic lab=S0}
C {devices/ipin.sym} 2800 -7760 1 0 {name=p8 sig_type=std_logic lab=S1}
C {devices/ipin.sym} 2420 -7710 1 0 {name=p17 sig_type=std_logic lab=S}
C {devices/vsource.sym} 4140 -5260 0 0 {name=VA17 value="pwl=0 1.8 100n 1.8 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 4140 -5290 0 0 {name=p27 sig_type=std_logic lab=S}
C {devices/vsource.sym} 4140 -5160 0 0 {name=VA18 value="pwl=0 1.8 50n 1.8 50n 0 80n 0 80n 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 4140 -5190 0 0 {name=p46 sig_type=std_logic lab=S0}
C {devices/vsource.sym} 4140 -5060 0 0 {name=VA26 value="pwl=0 1.8 800n 1.8 80n 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 4140 -5090 0 0 {name=VA27 sig_type=std_logic lab=S1}
C {devices/gnd.sym} 4140 -5030 0 0 {name=l67 lab=GND}
C {devices/gnd.sym} 4140 -5130 0 0 {name=l68 lab=GND}
C {devices/gnd.sym} 4140 -5230 0 0 {name=l69 lab=GND}
C {devices/lab_pin.sym} 2440 -7700 1 0 {name=p3 sig_type=std_logic lab=l}
C {devices/lab_pin.sym} 2380 -2720 1 0 {name=p4 sig_type=std_logic lab=l}
C {devices/lab_pin.sym} 2780 -2870 1 0 {name=p5 sig_type=std_logic lab=l}
C {devices/vsource.sym} 4530 -5060 0 0 {name=VA1 value="pwl=0 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 4530 -5090 0 0 {name=VA2 sig_type=std_logic lab=l}
C {devices/gnd.sym} 4530 -5030 0 0 {name=l33 lab=GND}
C {XOR2.sym} 2210 -8350 0 0 {name=x36}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 2880 -7780 3 0 {name=X38}
C {devices/lab_pin.sym} 2880 -7840 1 0 {name=p6 sig_type=std_logic lab=S0'}
C {devices/lab_pin.sym} 2350 -8330 0 0 {name=p7 sig_type=std_logic lab=S0'}
C {devices/lab_pin.sym} 2110 -8360 0 0 {name=p9 sig_type=std_logic lab=S}
C {devices/lab_pin.sym} 2110 -8340 0 0 {name=p10 sig_type=std_logic lab=S1}
C {AND3.sym} 2430 -8330 0 0 {name=x37}
C {devices/lab_pin.sym} 2350 -8310 0 0 {name=p11 sig_type=std_logic lab=Y1}
C {devices/lab_pin.sym} 2600 -7630 2 0 {name=p12 sig_type=std_logic lab=Y1}
C {devices/lab_pin.sym} 2510 -8330 2 0 {name=p13 sig_type=std_logic lab=Y1O}
C {devices/lab_pin.sym} 2740 -7630 0 0 {name=p14 sig_type=std_logic lab=Y1O}
C {XOR2.sym} 2210 -8240 0 0 {name=x39}
C {devices/lab_pin.sym} 2340 -8160 0 0 {name=p15 sig_type=std_logic lab=S0'}
C {devices/lab_pin.sym} 2110 -8250 0 0 {name=p18 sig_type=std_logic lab=S0}
C {devices/lab_pin.sym} 2110 -8230 0 0 {name=p19 sig_type=std_logic lab=S1}
C {AND3.sym} 2420 -8160 0 0 {name=x40}
C {devices/lab_pin.sym} 2340 -8140 0 0 {name=p20 sig_type=std_logic lab=S}
C {devices/lab_pin.sym} 2800 -8200 2 0 {name=p21 sig_type=std_logic lab=Y2O}
C {devices/lab_pin.sym} 2740 -7610 0 0 {name=p32 sig_type=std_logic lab=Y2O}
C {devices/lab_pin.sym} 2610 -7610 2 0 {name=p33 sig_type=std_logic lab=Y2}
C {AND2.sym} 2410 -8230 0 0 {name=x41}
C {devices/lab_pin.sym} 2350 -8220 0 0 {name=p34 sig_type=std_logic lab=S'}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 2370 -7720 3 0 {name=X42}
C {devices/lab_pin.sym} 2370 -7780 1 0 {name=p35 sig_type=std_logic lab=S'}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 2770 -7750 1 1 {name=X43}
C {devices/lab_pin.sym} 2770 -7810 3 1 {name=p41 sig_type=std_logic lab=S1'}
C {devices/lab_pin.sym} 2340 -8180 0 0 {name=p42 sig_type=std_logic lab=S1'}
C {OR2.sym} 2580 -8210 0 0 {name=x44}
C {AND2.sym} 2730 -8200 0 0 {name=x45}
C {devices/lab_pin.sym} 2660 -8190 0 0 {name=p43 sig_type=std_logic lab=Y2}
C {XOR2.sym} 2210 -8090 0 0 {name=x33}
C {devices/lab_pin.sym} 2340 -8010 0 0 {name=p44 sig_type=std_logic lab=S0'}
C {devices/lab_pin.sym} 2110 -8100 0 0 {name=p45 sig_type=std_logic lab=S0}
C {devices/lab_pin.sym} 2110 -8080 0 0 {name=p47 sig_type=std_logic lab=S1}
C {AND3.sym} 2420 -8010 0 0 {name=x34}
C {devices/lab_pin.sym} 2340 -7990 0 0 {name=p48 sig_type=std_logic lab=S}
C {devices/lab_pin.sym} 2800 -8050 2 0 {name=p49 sig_type=std_logic lab=Y3O}
C {AND2.sym} 2410 -8080 0 0 {name=x35}
C {devices/lab_pin.sym} 2350 -8070 0 0 {name=p50 sig_type=std_logic lab=S'}
C {devices/lab_pin.sym} 2340 -8030 0 0 {name=p51 sig_type=std_logic lab=S1'}
C {OR2.sym} 2580 -8060 0 0 {name=x46}
C {AND2.sym} 2730 -8050 0 0 {name=x47}
C {devices/lab_pin.sym} 2660 -8040 0 0 {name=p52 sig_type=std_logic lab=Y3}
C {devices/lab_pin.sym} 2740 -7460 0 0 {name=p53 sig_type=std_logic lab=Y3O}
C {devices/lab_pin.sym} 2620 -7460 2 0 {name=p54 sig_type=std_logic lab=Y3}
C {devices/lab_pin.sym} 2740 -7330 0 0 {name=p55 sig_type=std_logic lab=Y3O}
C {devices/lab_pin.sym} 2740 -7200 0 0 {name=p56 sig_type=std_logic lab=Y3O}
C {devices/lab_pin.sym} 2740 -7480 0 0 {name=p57 sig_type=std_logic lab=Y2O}
C {devices/lab_pin.sym} 2740 -7350 0 0 {name=p58 sig_type=std_logic lab=Y2O}
C {devices/lab_pin.sym} 2740 -7500 0 0 {name=p59 sig_type=std_logic lab=Y1O}
