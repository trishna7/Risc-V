v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
B 2 18830 -8480 19630 -8080 {flags=graph
y1=-0.4
y2=1.6
ypos1=-0.4
ypos2=1.6
divy=5
subdivy=1
unity=1
x1=6.466091e-08
x2=1.6466091e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="we
wl
rd
p_b"
color="4 10 12 15"
dataset=-1
unitx=1
logx=0
logy=0
digital=1}
B 2 18830 -8060 19630 -7660 {flags=graph
y1=-0.4
y2=1.6
ypos1=5
ypos2=7
divy=5
subdivy=1
unity=1
x1=6.466091e-08
x2=1.6466091e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0


digital=1

color="15 15 15 15 15 15 15 15 15 15 15 15 15 15 15 15 15 15 15 15 15 15 15 15 15 15 15 15 15 15 15 15 15"
node="di;d5,d4,d3,d2,d1,d0,d5,d4,d3,d2,d1,d0,d5,d4,d3,d2,d1,d0,d5,d4,d3,d2,d1,d0,d5,d4,d3,d2,d1,d0,d5,d4
d31
d30
d29
d28
d27
d26
d25
d24
d23
d22
d21
d20
d19
d18
d17
d16
d15
d14
d13
d12
d11
d10
d9
d8
d7
d6
d5
d4
d3
d2
d1
d0"}
B 2 18830 -7620 19630 -7220 {flags=graph
y1=-0.4
y2=1.6
ypos1=4.8
ypos2=6.8
divy=5
subdivy=1
unity=1
x1=6.466091e-08
x2=1.6466091e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0



digital=1

color="15 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4"
node="out;o31,o30,o29,o28,o27,o26,o25,o24,o23,o22,o21,o20,o19,o18,o17,o16,o15,o14,o13,o12,o11,o10,o9,o8,o7,o6,o5,o4,o3,o2,o1,o0
o31
o30
o29
o28
o27
o26
o25
o24
o23
o22
o21
o20
o19
o18
o17
o16
o15
o14
o13
o12
o11
o10
o9
o8
o7
o6
o5
o4
o3
o2
o1
o0"}
B 2 18830 -7180 19630 -6780 {flags=graph
y1=-0.4
y2=1.6
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.466091e-08
x2=1.6466091e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0


digital=1

color="15 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4"
node="outb;ob31,ob30,ob29,ob28,ob27,ob26,ob25,ob24,ob23,ob22,ob21,ob20,ob19,ob18,ob17,ob16,ob15,ob14,ob13,ob12,ob11,ob10,ob9,ob8,ob7,ob6,ob5,ob4,ob3,ob2,ob1,ob0
ob31
ob30
ob29
ob28
ob27
ob26
ob25
ob24
ob23
ob22
ob21
ob20
ob19
ob18
ob17
ob16
ob15
ob14
ob13
ob12
ob11
ob10
ob9
ob8
ob7
ob6
ob5
ob4
ob3
ob2
ob1
ob0"}
B 2 19650 -7620 20450 -7220 {flags=graph
y1=-0.4
y2=1.6
ypos1=5
ypos2=7
divy=5
subdivy=1
unity=1
x1=6.466091e-08
x2=1.6466091e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




digital=1

color="15 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4"
node="blb;blb31,blb30,blb29,blb28,blb27,blb26,blb25,blb24,blb23,blb22,blb21,blb20,blb19,blb18,blb17,blb16,blb15,blb14,blb13,blb12,blb11,blb10,blb9,blb8,blb7,blb6,blb5,blb4,blb3,blb2,blb1,blb0
blb31
blb30
blb29
blb28
blb27
blb26
blb25
blb24
blb23
blb22
blb21
blb20
blb19
blb18
blb17
blb16
blb15
blb14
blb13
blb12
blb11
blb10
blb9
blb8
blb7
blb6
blb5
blb4
blb3
blb2
blb1
blb0"}
B 2 19660 -7180 20460 -6780 {flags=graph
y1=-1.6
y2=0.4
ypos1=4.9
ypos2=6.9
divy=5
subdivy=1
unity=1
x1=6.466091e-08
x2=1.6466091e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0


digital=1
color="15 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4"
node="b;b31,b30,b29,b28,b27,b26,b25,b24,b23,b22,b21,b20,b19,b18,b17,b16,b15,b14,b13,b12,b11,b10,b9,b8,b7,b6,b5,b4,b3,b2,b1,b0
b31
b30
b29
b28
b27
b26
b25
b24
b23
b22
b21
b20
b19
b18
b17
b16
b15
b14
b13
b12
b11
b10
b9
b8
b7
b6
b5
b4
b3
b2
b1
b0"}
B 2 19670 -8480 20470 -8080 {flags=graph
y1=-0.4
y2=1.6
ypos1=4.9
ypos2=6.9
divy=5
subdivy=1
unity=1
x1=6.466091e-08
x2=1.6466091e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




digital=1
color="15 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4 4"
node="q;q31,q30,q29,q28,q27,q26,q25,q24,q23,q22,q21,q20,q19,q18,q17,q16,q15,q14,q13,q12,q11,q10,q9,q8,q7,q6,q5,q4,q3,q2,q1,q0
q31
q30
q29
q28
q27
q26
q25
q24
q23
q22
q21
q20
q19
q18
q17
q16
q15
q14
q13
q12
q11
q10
q9
q8
q7
q6
q5
q4
q3
q2
q1
q0"}
B 2 19670 -8050 20470 -7650 {flags=graph
y1=-0.4
y2=1.6
ypos1=4.9
ypos2=6.9
divy=5
subdivy=1
unity=1
x1=6.466091e-08
x2=1.6466091e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0



digital=1

color="15 15 15 15 15 15 15 15 15 15 15 15 15 15 15 15 15 15 15 15 15 15 15 15 15 15 15 15 15 15 15 15 15"
node="qb;qb31,qb30,qb29,qb28,qb27,qb26,qb25,qb24,qb23,qb22,qb21,qb20,qb19,qb18,qb17,qb16,qb15,qb14,qb13,qb12,qb11,qb10,qb9,qb8,qb7,qb6,qb5,qb4,qb3,qb2,qb1,qb0
qb31
qb30
qb29
qb28
qb27
qb26
qb25
qb24
qb23
qb22
qb21
qb20
qb19
qb18
qb17
qb16
qb15
qb14
qb13
qb12
qb11
qb10
qb9
qb8
qb7
qb6
qb5
qb4
qb3
qb2
qb1
qb0"}
N 3270 -13290 3290 -13290 {
lab=blb0}
N 3270 -13270 3300 -13270 {
lab=b0}
N 4040 -13380 4040 -13290 {
lab=q0}
N 4200 -13380 4200 -13290 {
lab=qb0}
N 4080 -13410 4080 -13260 {
lab=qb0}
N 4160 -13410 4160 -13260 {
lab=q0}
N 4040 -13470 4040 -13440 {
lab=VDD}
N 4040 -13470 4200 -13470 {
lab=VDD}
N 4200 -13470 4200 -13440 {
lab=VDD}
N 4040 -13230 4040 -13190 {
lab=GND}
N 4040 -13190 4200 -13190 {
lab=GND}
N 4200 -13230 4200 -13190 {
lab=GND}
N 4120 -13190 4120 -13170 {
lab=GND}
N 4120 -13490 4120 -13470 {
lab=VDD}
N 3890 -13310 4040 -13310 {
lab=q0}
N 4200 -13320 4320 -13320 {
lab=qb0}
N 4080 -13320 4200 -13320 {
lab=qb0}
N 3780 -13310 3830 -13310 {
lab=b0}
N 4380 -13320 4420 -13320 {
lab=blb0}
N 3860 -13530 3860 -13350 {
lab=WL}
N 3860 -13530 4350 -13530 {
lab=WL}
N 4350 -13530 4350 -13360 {
lab=WL}
N 3780 -13530 3860 -13530 {
lab=WL}
N 4040 -13310 4160 -13310 {
lab=q0}
N 4280 -13360 4280 -13320 {
lab=qb0}
N 3950 -13350 3950 -13310 {
lab=q0}
N 3300 -13270 3780 -13270 {
lab=b0}
N 3780 -13310 3780 -13270 {
lab=b0}
N 3290 -13290 3770 -13290 {
lab=blb0}
N 3770 -13290 3770 -13130 {
lab=blb0}
N 3770 -13130 4430 -13130 {
lab=blb0}
N 4430 -13320 4430 -13130 {
lab=blb0}
N 4420 -13320 4430 -13320 {
lab=blb0}
N 3360 -12860 3360 -12750 {
lab=blb0}
N 3280 -12890 3320 -12890 {
lab=d0}
N 3280 -12890 3280 -12720 {
lab=d0}
N 3280 -12720 3320 -12720 {
lab=d0}
N 3360 -12370 3360 -12330 {
lab=#net1}
N 3360 -12270 3360 -12160 {
lab=b0}
N 3360 -12100 3360 -12060 {
lab=#net2}
N 3280 -12300 3320 -12300 {
lab=#net3}
N 3280 -12300 3280 -12130 {
lab=#net3}
N 3280 -12130 3320 -12130 {
lab=#net3}
N 3110 -12030 3320 -12030 {
lab=we}
N 3040 -12030 3110 -12030 {
lab=we}
N 3040 -12830 3040 -12030 {
lab=we}
N 3040 -12840 3040 -12830 {
lab=we}
N 3040 -12840 3100 -12840 {
lab=we}
N 3040 -12620 3320 -12620 {
lab=we}
N 3050 -12810 3050 -12730 {
lab=d0}
N 3050 -12810 3280 -12810 {
lab=d0}
N 3050 -12740 3050 -12210 {
lab=d0}
N 3050 -12210 3080 -12210 {
lab=d0}
N 3140 -12210 3280 -12210 {
lab=#net3}
N 3360 -12000 3360 -11960 {
lab=GND}
N 3360 -12590 3360 -12550 {
lab=GND}
N 3360 -13060 3360 -13020 {
lab=VDD}
N 3360 -12450 3360 -12430 {
lab=VDD}
N 3360 -12810 3520 -12810 {
lab=blb0}
N 3360 -12220 3510 -12220 {
lab=b0}
N 3510 -12220 3520 -12220 {
lab=b0}
N 2960 -12840 3040 -12840 {
lab=we}
N 2960 -12210 3050 -12210 {
lab=d0}
N 3490 -13290 3490 -12810 {
lab=blb0}
N 3500 -13270 3500 -12220 {
lab=b0}
N 2950 -13420 2950 -13330 {
lab=b0}
N 2860 -13420 2950 -13420 {
lab=b0}
N 2950 -13270 2950 -13200 {
lab=blb0}
N 2860 -13200 2950 -13200 {
lab=blb0}
N 2760 -13200 2800 -13200 {
lab=VDD}
N 2760 -13420 2760 -13200 {
lab=VDD}
N 2760 -13420 2800 -13420 {
lab=VDD}
N 2910 -13300 2910 -13130 {
lab=p_b}
N 2760 -13200 2760 -13120 {
lab=VDD}
N 2950 -13420 3020 -13420 {
lab=b0}
N 2830 -13380 2830 -13240 {
lab=p_b}
N 2830 -13270 2910 -13270 {
lab=p_b}
N 3170 -13290 3270 -13290 {
lab=blb0}
N 3170 -13290 3170 -13210 {
lab=blb0}
N 2950 -13210 3170 -13210 {
lab=blb0}
N 3020 -13270 3270 -13270 {
lab=b0}
N 3020 -13420 3020 -13270 {
lab=b0}
N 4220 -12820 4310 -12820 {
lab=o0}
N 4310 -12910 4310 -12820 {
lab=o0}
N 4090 -12820 4160 -12820 {
lab=ob0}
N 4090 -12910 4090 -12820 {
lab=ob0}
N 4090 -13010 4090 -12970 {
lab=VDD}
N 4090 -13010 4310 -13010 {
lab=VDD}
N 4310 -13010 4310 -12970 {
lab=VDD}
N 4020 -12860 4190 -12860 {
lab=p_b}
N 4010 -13010 4090 -13010 {
lab=VDD}
N 4020 -12820 4090 -12820 {
lab=ob0}
N 4130 -12940 4270 -12940 {
lab=p_b}
N 4160 -12940 4160 -12860 {
lab=p_b}
N 4310 -12720 4310 -12700 {
lab=VDD}
N 4090 -12720 4310 -12720 {
lab=VDD}
N 4090 -12720 4090 -12710 {
lab=VDD}
N 4130 -12680 4230 -12680 {
lab=o0}
N 4230 -12680 4230 -12620 {
lab=o0}
N 4230 -12620 4310 -12620 {
lab=o0}
N 4310 -12640 4310 -12620 {
lab=o0}
N 4350 -12670 4380 -12670 {
lab=ob0}
N 4380 -12670 4380 -12600 {
lab=ob0}
N 4090 -12600 4380 -12600 {
lab=ob0}
N 4090 -12650 4090 -12600 {
lab=ob0}
N 4310 -12620 4310 -12540 {
lab=o0}
N 4090 -12600 4090 -12550 {
lab=ob0}
N 4090 -12490 4090 -12460 {
lab=#net4}
N 4090 -12460 4310 -12460 {
lab=#net4}
N 4310 -12480 4310 -12460 {
lab=#net4}
N 4180 -12460 4180 -12400 {
lab=#net4}
N 4180 -12340 4180 -12310 {
lab=GND}
N 4060 -12370 4140 -12370 {
lab=VDD}
N 4030 -12520 4050 -12520 {
lab=o0}
N 4030 -12620 4030 -12520 {
lab=o0}
N 4030 -12620 4150 -12620 {
lab=o0}
N 4150 -12680 4150 -12620 {
lab=o0}
N 4240 -12510 4270 -12510 {
lab=ob0}
N 4240 -12600 4240 -12510 {
lab=ob0}
N 3990 -12600 4090 -12600 {
lab=ob0}
N 3990 -12820 3990 -12600 {
lab=ob0}
N 3990 -12820 4030 -12820 {
lab=ob0}
N 4310 -12820 4420 -12820 {
lab=o0}
N 4420 -12820 4420 -12590 {
lab=o0}
N 4310 -12590 4420 -12590 {
lab=o0}
N 3870 -12600 3990 -12600 {
lab=ob0}
N 4420 -12590 4510 -12590 {
lab=o0}
N 3840 -12690 3840 -12640 {
lab=rd}
N 4540 -12670 4540 -12630 {
lab=rd}
N 4570 -12590 4640 -12590 {
lab=b0}
N 3750 -12600 3810 -12600 {
lab=blb0}
N 4460 -12660 4460 -12590 {
lab=o0}
N 3930 -12690 3930 -12600 {
lab=ob0}
N 3760 -13130 3760 -12600 {
lab=blb0}
N 3760 -13130 3770 -13130 {
lab=blb0}
N 4620 -13070 4620 -12590 {
lab=b0}
N 3780 -13070 4620 -13070 {
lab=b0}
N 3780 -13270 3780 -13070 {
lab=b0}
N 3600 -13300 3600 -13290 {
lab=blb0}
N 3560 -13300 3560 -13270 {
lab=b0}
N 3360 -12960 3360 -12920 {
lab=#net5}
N 3360 -12690 3360 -12650 {
lab=#net6}
N 3160 -12990 3320 -12990 {
lab=#net7}
N 3160 -12990 3160 -12840 {
lab=#net7}
N 3160 -12840 3160 -12400 {
lab=#net7}
N 3160 -12400 3320 -12400 {
lab=#net7}
N 5590 -13270 5610 -13270 {
lab=blb1}
N 5590 -13250 5620 -13250 {
lab=b1}
N 6360 -13360 6360 -13270 {
lab=q1}
N 6520 -13360 6520 -13270 {
lab=qb1}
N 6400 -13390 6400 -13240 {
lab=qb1}
N 6480 -13390 6480 -13240 {
lab=q1}
N 6360 -13450 6360 -13420 {
lab=VDD}
N 6360 -13450 6520 -13450 {
lab=VDD}
N 6520 -13450 6520 -13420 {
lab=VDD}
N 6360 -13210 6360 -13170 {
lab=GND}
N 6360 -13170 6520 -13170 {
lab=GND}
N 6520 -13210 6520 -13170 {
lab=GND}
N 6440 -13170 6440 -13150 {
lab=GND}
N 6440 -13470 6440 -13450 {
lab=VDD}
N 6210 -13290 6360 -13290 {
lab=q1}
N 6520 -13300 6640 -13300 {
lab=qb1}
N 6400 -13300 6520 -13300 {
lab=qb1}
N 6100 -13290 6150 -13290 {
lab=b1}
N 6700 -13300 6740 -13300 {
lab=blb1}
N 6180 -13510 6180 -13330 {
lab=WL}
N 6180 -13510 6670 -13510 {
lab=WL}
N 6670 -13510 6670 -13340 {
lab=WL}
N 6100 -13510 6180 -13510 {
lab=WL}
N 6360 -13290 6480 -13290 {
lab=q1}
N 6600 -13340 6600 -13300 {
lab=qb1}
N 6270 -13330 6270 -13290 {
lab=q1}
N 5620 -13250 6100 -13250 {
lab=b1}
N 6100 -13290 6100 -13250 {
lab=b1}
N 5610 -13270 6090 -13270 {
lab=blb1}
N 6090 -13270 6090 -13110 {
lab=blb1}
N 6090 -13110 6750 -13110 {
lab=blb1}
N 6750 -13300 6750 -13110 {
lab=blb1}
N 6740 -13300 6750 -13300 {
lab=blb1}
N 5680 -12840 5680 -12730 {
lab=blb1}
N 5600 -12870 5640 -12870 {
lab=d1}
N 5600 -12870 5600 -12700 {
lab=d1}
N 5600 -12700 5640 -12700 {
lab=d1}
N 5680 -12350 5680 -12310 {
lab=#net8}
N 5680 -12250 5680 -12140 {
lab=b1}
N 5680 -12080 5680 -12040 {
lab=#net9}
N 5600 -12280 5640 -12280 {
lab=#net10}
N 5600 -12280 5600 -12110 {
lab=#net10}
N 5600 -12110 5640 -12110 {
lab=#net10}
N 5430 -12010 5640 -12010 {
lab=we}
N 5360 -12010 5430 -12010 {
lab=we}
N 5360 -12810 5360 -12010 {
lab=we}
N 5360 -12820 5360 -12810 {
lab=we}
N 5360 -12820 5420 -12820 {
lab=we}
N 5360 -12600 5640 -12600 {
lab=we}
N 5370 -12790 5370 -12710 {
lab=d1}
N 5370 -12790 5600 -12790 {
lab=d1}
N 5370 -12720 5370 -12190 {
lab=d1}
N 5370 -12190 5400 -12190 {
lab=d1}
N 5460 -12190 5600 -12190 {
lab=#net10}
N 5680 -11980 5680 -11940 {
lab=GND}
N 5680 -12570 5680 -12530 {
lab=GND}
N 5680 -13040 5680 -13000 {
lab=VDD}
N 5680 -12430 5680 -12410 {
lab=VDD}
N 5680 -12790 5840 -12790 {
lab=blb1}
N 5680 -12200 5830 -12200 {
lab=b1}
N 5830 -12200 5840 -12200 {
lab=b1}
N 5280 -12820 5360 -12820 {
lab=we}
N 5280 -12190 5370 -12190 {
lab=d1}
N 5810 -13270 5810 -12790 {
lab=blb1}
N 5820 -13250 5820 -12200 {
lab=b1}
N 5270 -13400 5270 -13310 {
lab=b1}
N 5180 -13400 5270 -13400 {
lab=b1}
N 5270 -13250 5270 -13180 {
lab=blb1}
N 5180 -13180 5270 -13180 {
lab=blb1}
N 5080 -13180 5120 -13180 {
lab=VDD}
N 5080 -13400 5080 -13180 {
lab=VDD}
N 5080 -13400 5120 -13400 {
lab=VDD}
N 5230 -13280 5230 -13110 {
lab=p_b}
N 5080 -13180 5080 -13100 {
lab=VDD}
N 5270 -13400 5340 -13400 {
lab=b1}
N 5150 -13360 5150 -13220 {
lab=p_b}
N 5150 -13250 5230 -13250 {
lab=p_b}
N 5490 -13270 5590 -13270 {
lab=blb1}
N 5490 -13270 5490 -13190 {
lab=blb1}
N 5270 -13190 5490 -13190 {
lab=blb1}
N 5340 -13250 5590 -13250 {
lab=b1}
N 5340 -13400 5340 -13250 {
lab=b1}
N 6540 -12800 6630 -12800 {
lab=o1}
N 6630 -12890 6630 -12800 {
lab=o1}
N 6410 -12800 6480 -12800 {
lab=ob1}
N 6410 -12890 6410 -12800 {
lab=ob1}
N 6410 -12990 6410 -12950 {
lab=VDD}
N 6410 -12990 6630 -12990 {
lab=VDD}
N 6630 -12990 6630 -12950 {
lab=VDD}
N 6340 -12840 6510 -12840 {
lab=p_b}
N 6330 -12990 6410 -12990 {
lab=VDD}
N 6340 -12800 6410 -12800 {
lab=ob1}
N 6450 -12920 6590 -12920 {
lab=p_b}
N 6480 -12920 6480 -12840 {
lab=p_b}
N 6630 -12700 6630 -12680 {
lab=VDD}
N 6410 -12700 6630 -12700 {
lab=VDD}
N 6410 -12700 6410 -12690 {
lab=VDD}
N 6450 -12660 6550 -12660 {
lab=o1}
N 6550 -12660 6550 -12600 {
lab=o1}
N 6550 -12600 6630 -12600 {
lab=o1}
N 6630 -12620 6630 -12600 {
lab=o1}
N 6670 -12650 6700 -12650 {
lab=ob1}
N 6700 -12650 6700 -12580 {
lab=ob1}
N 6410 -12580 6700 -12580 {
lab=ob1}
N 6410 -12630 6410 -12580 {
lab=ob1}
N 6630 -12600 6630 -12520 {
lab=o1}
N 6410 -12580 6410 -12530 {
lab=ob1}
N 6410 -12470 6410 -12440 {
lab=#net11}
N 6410 -12440 6630 -12440 {
lab=#net11}
N 6630 -12460 6630 -12440 {
lab=#net11}
N 6500 -12440 6500 -12380 {
lab=#net11}
N 6500 -12320 6500 -12290 {
lab=GND}
N 6380 -12350 6460 -12350 {
lab=VDD}
N 6350 -12500 6370 -12500 {
lab=o1}
N 6350 -12600 6350 -12500 {
lab=o1}
N 6350 -12600 6470 -12600 {
lab=o1}
N 6470 -12660 6470 -12600 {
lab=o1}
N 6560 -12490 6590 -12490 {
lab=ob1}
N 6560 -12580 6560 -12490 {
lab=ob1}
N 6310 -12580 6410 -12580 {
lab=ob1}
N 6310 -12800 6310 -12580 {
lab=ob1}
N 6310 -12800 6350 -12800 {
lab=ob1}
N 6630 -12800 6740 -12800 {
lab=o1}
N 6740 -12800 6740 -12570 {
lab=o1}
N 6630 -12570 6740 -12570 {
lab=o1}
N 6190 -12580 6310 -12580 {
lab=ob1}
N 6740 -12570 6830 -12570 {
lab=o1}
N 6160 -12670 6160 -12620 {
lab=rd}
N 6860 -12650 6860 -12610 {
lab=rd}
N 6890 -12570 6960 -12570 {
lab=b1}
N 6070 -12580 6130 -12580 {
lab=blb1}
N 6780 -12640 6780 -12570 {
lab=o1}
N 6250 -12670 6250 -12580 {
lab=ob1}
N 6080 -13110 6080 -12580 {
lab=blb1}
N 6080 -13110 6090 -13110 {
lab=blb1}
N 6940 -13050 6940 -12570 {
lab=b1}
N 6100 -13050 6940 -13050 {
lab=b1}
N 6100 -13250 6100 -13050 {
lab=b1}
N 5920 -13280 5920 -13270 {
lab=blb1}
N 5880 -13280 5880 -13250 {
lab=b1}
N 5680 -12940 5680 -12900 {
lab=#net12}
N 5680 -12670 5680 -12630 {
lab=#net13}
N 5480 -12970 5640 -12970 {
lab=#net14}
N 5480 -12970 5480 -12820 {
lab=#net14}
N 5480 -12820 5480 -12380 {
lab=#net14}
N 5480 -12380 5640 -12380 {
lab=#net14}
N 7740 -13260 7760 -13260 {
lab=blb2}
N 7740 -13240 7770 -13240 {
lab=b2}
N 8510 -13350 8510 -13260 {
lab=q2}
N 8670 -13350 8670 -13260 {
lab=qb2}
N 8550 -13380 8550 -13230 {
lab=qb2}
N 8630 -13380 8630 -13230 {
lab=q2}
N 8510 -13440 8510 -13410 {
lab=VDD}
N 8510 -13440 8670 -13440 {
lab=VDD}
N 8670 -13440 8670 -13410 {
lab=VDD}
N 8510 -13200 8510 -13160 {
lab=GND}
N 8510 -13160 8670 -13160 {
lab=GND}
N 8670 -13200 8670 -13160 {
lab=GND}
N 8590 -13160 8590 -13140 {
lab=GND}
N 8590 -13460 8590 -13440 {
lab=VDD}
N 8360 -13280 8510 -13280 {
lab=q2}
N 8670 -13290 8790 -13290 {
lab=qb2}
N 8550 -13290 8670 -13290 {
lab=qb2}
N 8250 -13280 8300 -13280 {
lab=b2}
N 8850 -13290 8890 -13290 {
lab=blb2}
N 8330 -13500 8330 -13320 {
lab=WL}
N 8330 -13500 8820 -13500 {
lab=WL}
N 8820 -13500 8820 -13330 {
lab=WL}
N 8250 -13500 8330 -13500 {
lab=WL}
N 8510 -13280 8630 -13280 {
lab=q2}
N 8750 -13330 8750 -13290 {
lab=qb2}
N 8420 -13320 8420 -13280 {
lab=q2}
N 7770 -13240 8250 -13240 {
lab=b2}
N 8250 -13280 8250 -13240 {
lab=b2}
N 7760 -13260 8240 -13260 {
lab=blb2}
N 8240 -13260 8240 -13100 {
lab=blb2}
N 8240 -13100 8900 -13100 {
lab=blb2}
N 8900 -13290 8900 -13100 {
lab=blb2}
N 8890 -13290 8900 -13290 {
lab=blb2}
N 7830 -12830 7830 -12720 {
lab=blb2}
N 7750 -12860 7790 -12860 {
lab=d2}
N 7750 -12860 7750 -12690 {
lab=d2}
N 7750 -12690 7790 -12690 {
lab=d2}
N 7830 -12340 7830 -12300 {
lab=#net15}
N 7830 -12240 7830 -12130 {
lab=b2}
N 7830 -12070 7830 -12030 {
lab=#net16}
N 7750 -12270 7790 -12270 {
lab=#net17}
N 7750 -12270 7750 -12100 {
lab=#net17}
N 7750 -12100 7790 -12100 {
lab=#net17}
N 7580 -12000 7790 -12000 {
lab=we}
N 7510 -12000 7580 -12000 {
lab=we}
N 7510 -12800 7510 -12000 {
lab=we}
N 7510 -12810 7510 -12800 {
lab=we}
N 7510 -12810 7570 -12810 {
lab=we}
N 7510 -12590 7790 -12590 {
lab=we}
N 7520 -12780 7520 -12700 {
lab=d2}
N 7520 -12780 7750 -12780 {
lab=d2}
N 7520 -12710 7520 -12180 {
lab=d2}
N 7520 -12180 7550 -12180 {
lab=d2}
N 7610 -12180 7750 -12180 {
lab=#net17}
N 7830 -11970 7830 -11930 {
lab=GND}
N 7830 -12560 7830 -12520 {
lab=GND}
N 7830 -13030 7830 -12990 {
lab=VDD}
N 7830 -12420 7830 -12400 {
lab=VDD}
N 7830 -12780 7990 -12780 {
lab=blb2}
N 7830 -12190 7980 -12190 {
lab=b2}
N 7980 -12190 7990 -12190 {
lab=b2}
N 7430 -12810 7510 -12810 {
lab=we}
N 7430 -12180 7520 -12180 {
lab=d2}
N 7960 -13260 7960 -12780 {
lab=blb2}
N 7970 -13240 7970 -12190 {
lab=b2}
N 7420 -13390 7420 -13300 {
lab=b2}
N 7330 -13390 7420 -13390 {
lab=b2}
N 7420 -13240 7420 -13170 {
lab=blb2}
N 7330 -13170 7420 -13170 {
lab=blb2}
N 7230 -13170 7270 -13170 {
lab=VDD}
N 7230 -13390 7230 -13170 {
lab=VDD}
N 7230 -13390 7270 -13390 {
lab=VDD}
N 7380 -13270 7380 -13100 {
lab=p_b}
N 7230 -13170 7230 -13090 {
lab=VDD}
N 7420 -13390 7490 -13390 {
lab=b2}
N 7300 -13350 7300 -13210 {
lab=p_b}
N 7300 -13240 7380 -13240 {
lab=p_b}
N 7640 -13260 7740 -13260 {
lab=blb2}
N 7640 -13260 7640 -13180 {
lab=blb2}
N 7420 -13180 7640 -13180 {
lab=blb2}
N 7490 -13240 7740 -13240 {
lab=b2}
N 7490 -13390 7490 -13240 {
lab=b2}
N 8690 -12790 8780 -12790 {
lab=o2}
N 8780 -12880 8780 -12790 {
lab=o2}
N 8560 -12790 8630 -12790 {
lab=ob2}
N 8560 -12880 8560 -12790 {
lab=ob2}
N 8560 -12980 8560 -12940 {
lab=VDD}
N 8560 -12980 8780 -12980 {
lab=VDD}
N 8780 -12980 8780 -12940 {
lab=VDD}
N 8490 -12830 8660 -12830 {
lab=p_b}
N 8480 -12980 8560 -12980 {
lab=VDD}
N 8490 -12790 8560 -12790 {
lab=ob2}
N 8600 -12910 8740 -12910 {
lab=p_b}
N 8630 -12910 8630 -12830 {
lab=p_b}
N 8780 -12690 8780 -12670 {
lab=VDD}
N 8560 -12690 8780 -12690 {
lab=VDD}
N 8560 -12690 8560 -12680 {
lab=VDD}
N 8600 -12650 8700 -12650 {
lab=o2}
N 8700 -12650 8700 -12590 {
lab=o2}
N 8700 -12590 8780 -12590 {
lab=o2}
N 8780 -12610 8780 -12590 {
lab=o2}
N 8820 -12640 8850 -12640 {
lab=ob2}
N 8850 -12640 8850 -12570 {
lab=ob2}
N 8560 -12570 8850 -12570 {
lab=ob2}
N 8560 -12620 8560 -12570 {
lab=ob2}
N 8780 -12590 8780 -12510 {
lab=o2}
N 8560 -12570 8560 -12520 {
lab=ob2}
N 8560 -12460 8560 -12430 {
lab=#net18}
N 8560 -12430 8780 -12430 {
lab=#net18}
N 8780 -12450 8780 -12430 {
lab=#net18}
N 8650 -12430 8650 -12370 {
lab=#net18}
N 8650 -12310 8650 -12280 {
lab=GND}
N 8530 -12340 8610 -12340 {
lab=VDD}
N 8500 -12490 8520 -12490 {
lab=o2}
N 8500 -12590 8500 -12490 {
lab=o2}
N 8500 -12590 8620 -12590 {
lab=o2}
N 8620 -12650 8620 -12590 {
lab=o2}
N 8710 -12480 8740 -12480 {
lab=ob2}
N 8710 -12570 8710 -12480 {
lab=ob2}
N 8460 -12570 8560 -12570 {
lab=ob2}
N 8460 -12790 8460 -12570 {
lab=ob2}
N 8460 -12790 8500 -12790 {
lab=ob2}
N 8780 -12790 8890 -12790 {
lab=o2}
N 8890 -12790 8890 -12560 {
lab=o2}
N 8780 -12560 8890 -12560 {
lab=o2}
N 8340 -12570 8460 -12570 {
lab=ob2}
N 8890 -12560 8980 -12560 {
lab=o2}
N 8310 -12660 8310 -12610 {
lab=rd}
N 9010 -12640 9010 -12600 {
lab=rd}
N 9040 -12560 9110 -12560 {
lab=b2}
N 8220 -12570 8280 -12570 {
lab=blb2}
N 8930 -12630 8930 -12560 {
lab=o2}
N 8400 -12660 8400 -12570 {
lab=ob2}
N 8230 -13100 8230 -12570 {
lab=blb2}
N 8230 -13100 8240 -13100 {
lab=blb2}
N 9090 -13040 9090 -12560 {
lab=b2}
N 8250 -13040 9090 -13040 {
lab=b2}
N 8250 -13240 8250 -13040 {
lab=b2}
N 8070 -13270 8070 -13260 {
lab=blb2}
N 8030 -13270 8030 -13240 {
lab=b2}
N 7830 -12930 7830 -12890 {
lab=#net19}
N 7830 -12660 7830 -12620 {
lab=#net20}
N 7630 -12960 7790 -12960 {
lab=#net21}
N 7630 -12960 7630 -12810 {
lab=#net21}
N 7630 -12810 7630 -12370 {
lab=#net21}
N 7630 -12370 7790 -12370 {
lab=#net21}
N 9870 -13260 9890 -13260 {
lab=blb3}
N 9870 -13240 9900 -13240 {
lab=b3}
N 10640 -13350 10640 -13260 {
lab=q3}
N 10800 -13350 10800 -13260 {
lab=qb3}
N 10680 -13380 10680 -13230 {
lab=qb3}
N 10760 -13380 10760 -13230 {
lab=q3}
N 10640 -13440 10640 -13410 {
lab=VDD}
N 10640 -13440 10800 -13440 {
lab=VDD}
N 10800 -13440 10800 -13410 {
lab=VDD}
N 10640 -13200 10640 -13160 {
lab=GND}
N 10640 -13160 10800 -13160 {
lab=GND}
N 10800 -13200 10800 -13160 {
lab=GND}
N 10720 -13160 10720 -13140 {
lab=GND}
N 10720 -13460 10720 -13440 {
lab=VDD}
N 10490 -13280 10640 -13280 {
lab=q3}
N 10800 -13290 10920 -13290 {
lab=qb3}
N 10680 -13290 10800 -13290 {
lab=qb3}
N 10380 -13280 10430 -13280 {
lab=b3}
N 10980 -13290 11020 -13290 {
lab=blb3}
N 10460 -13500 10460 -13320 {
lab=WL}
N 10460 -13500 10950 -13500 {
lab=WL}
N 10950 -13500 10950 -13330 {
lab=WL}
N 10380 -13500 10460 -13500 {
lab=WL}
N 10640 -13280 10760 -13280 {
lab=q3}
N 10880 -13330 10880 -13290 {
lab=qb3}
N 10550 -13320 10550 -13280 {
lab=q3}
N 9900 -13240 10380 -13240 {
lab=b3}
N 10380 -13280 10380 -13240 {
lab=b3}
N 9890 -13260 10370 -13260 {
lab=blb3}
N 10370 -13260 10370 -13100 {
lab=blb3}
N 10370 -13100 11030 -13100 {
lab=blb3}
N 11030 -13290 11030 -13100 {
lab=blb3}
N 11020 -13290 11030 -13290 {
lab=blb3}
N 9960 -12830 9960 -12720 {
lab=blb3}
N 9880 -12860 9920 -12860 {
lab=d3}
N 9880 -12860 9880 -12690 {
lab=d3}
N 9880 -12690 9920 -12690 {
lab=d3}
N 9960 -12340 9960 -12300 {
lab=#net22}
N 9960 -12240 9960 -12130 {
lab=b3}
N 9960 -12070 9960 -12030 {
lab=#net23}
N 9880 -12270 9920 -12270 {
lab=#net24}
N 9880 -12270 9880 -12100 {
lab=#net24}
N 9880 -12100 9920 -12100 {
lab=#net24}
N 9710 -12000 9920 -12000 {
lab=we}
N 9640 -12000 9710 -12000 {
lab=we}
N 9640 -12800 9640 -12000 {
lab=we}
N 9640 -12810 9640 -12800 {
lab=we}
N 9640 -12810 9700 -12810 {
lab=we}
N 9640 -12590 9920 -12590 {
lab=we}
N 9650 -12780 9650 -12700 {
lab=d3}
N 9650 -12780 9880 -12780 {
lab=d3}
N 9650 -12710 9650 -12180 {
lab=d3}
N 9650 -12180 9680 -12180 {
lab=d3}
N 9740 -12180 9880 -12180 {
lab=#net24}
N 9960 -11970 9960 -11930 {
lab=GND}
N 9960 -12560 9960 -12520 {
lab=GND}
N 9960 -13030 9960 -12990 {
lab=VDD}
N 9960 -12420 9960 -12400 {
lab=VDD}
N 9960 -12780 10120 -12780 {
lab=blb3}
N 9960 -12190 10110 -12190 {
lab=b3}
N 10110 -12190 10120 -12190 {
lab=b3}
N 9560 -12810 9640 -12810 {
lab=we}
N 9560 -12180 9650 -12180 {
lab=d3}
N 10090 -13260 10090 -12780 {
lab=blb3}
N 10100 -13240 10100 -12190 {
lab=b3}
N 9550 -13390 9550 -13300 {
lab=b3}
N 9460 -13390 9550 -13390 {
lab=b3}
N 9550 -13240 9550 -13170 {
lab=blb3}
N 9460 -13170 9550 -13170 {
lab=blb3}
N 9360 -13170 9400 -13170 {
lab=VDD}
N 9360 -13390 9360 -13170 {
lab=VDD}
N 9360 -13390 9400 -13390 {
lab=VDD}
N 9510 -13270 9510 -13100 {
lab=p_b}
N 9360 -13170 9360 -13090 {
lab=VDD}
N 9550 -13390 9620 -13390 {
lab=b3}
N 9430 -13350 9430 -13210 {
lab=p_b}
N 9430 -13240 9510 -13240 {
lab=p_b}
N 9770 -13260 9870 -13260 {
lab=blb3}
N 9770 -13260 9770 -13180 {
lab=blb3}
N 9550 -13180 9770 -13180 {
lab=blb3}
N 9620 -13240 9870 -13240 {
lab=b3}
N 9620 -13390 9620 -13240 {
lab=b3}
N 10820 -12790 10910 -12790 {
lab=o3}
N 10910 -12880 10910 -12790 {
lab=o3}
N 10690 -12790 10760 -12790 {
lab=ob3}
N 10690 -12880 10690 -12790 {
lab=ob3}
N 10690 -12980 10690 -12940 {
lab=VDD}
N 10690 -12980 10910 -12980 {
lab=VDD}
N 10910 -12980 10910 -12940 {
lab=VDD}
N 10620 -12830 10790 -12830 {
lab=p_b}
N 10610 -12980 10690 -12980 {
lab=VDD}
N 10620 -12790 10690 -12790 {
lab=ob3}
N 10730 -12910 10870 -12910 {
lab=p_b}
N 10760 -12910 10760 -12830 {
lab=p_b}
N 10910 -12690 10910 -12670 {
lab=VDD}
N 10690 -12690 10910 -12690 {
lab=VDD}
N 10690 -12690 10690 -12680 {
lab=VDD}
N 10730 -12650 10830 -12650 {
lab=o3}
N 10830 -12650 10830 -12590 {
lab=o3}
N 10830 -12590 10910 -12590 {
lab=o3}
N 10910 -12610 10910 -12590 {
lab=o3}
N 10950 -12640 10980 -12640 {
lab=ob3}
N 10980 -12640 10980 -12570 {
lab=ob3}
N 10690 -12570 10980 -12570 {
lab=ob3}
N 10690 -12620 10690 -12570 {
lab=ob3}
N 10910 -12590 10910 -12510 {
lab=o3}
N 10690 -12570 10690 -12520 {
lab=ob3}
N 10690 -12460 10690 -12430 {
lab=#net25}
N 10690 -12430 10910 -12430 {
lab=#net25}
N 10910 -12450 10910 -12430 {
lab=#net25}
N 10780 -12430 10780 -12370 {
lab=#net25}
N 10780 -12310 10780 -12280 {
lab=GND}
N 10660 -12340 10740 -12340 {
lab=VDD}
N 10630 -12490 10650 -12490 {
lab=o3}
N 10630 -12590 10630 -12490 {
lab=o3}
N 10630 -12590 10750 -12590 {
lab=o3}
N 10750 -12650 10750 -12590 {
lab=o3}
N 10840 -12480 10870 -12480 {
lab=ob3}
N 10840 -12570 10840 -12480 {
lab=ob3}
N 10590 -12570 10690 -12570 {
lab=ob3}
N 10590 -12790 10590 -12570 {
lab=ob3}
N 10590 -12790 10630 -12790 {
lab=ob3}
N 10910 -12790 11020 -12790 {
lab=o3}
N 11020 -12790 11020 -12560 {
lab=o3}
N 10910 -12560 11020 -12560 {
lab=o3}
N 10470 -12570 10590 -12570 {
lab=ob3}
N 11020 -12560 11110 -12560 {
lab=o3}
N 10440 -12660 10440 -12610 {
lab=rd}
N 11140 -12640 11140 -12600 {
lab=rd}
N 11170 -12560 11240 -12560 {
lab=b3}
N 10350 -12570 10410 -12570 {
lab=blb3}
N 11060 -12630 11060 -12560 {
lab=o3}
N 10530 -12660 10530 -12570 {
lab=ob3}
N 10360 -13100 10360 -12570 {
lab=blb3}
N 10360 -13100 10370 -13100 {
lab=blb3}
N 11220 -13040 11220 -12560 {
lab=b3}
N 10380 -13040 11220 -13040 {
lab=b3}
N 10380 -13240 10380 -13040 {
lab=b3}
N 10200 -13270 10200 -13260 {
lab=blb3}
N 10160 -13270 10160 -13240 {
lab=b3}
N 9960 -12930 9960 -12890 {
lab=#net26}
N 9960 -12660 9960 -12620 {
lab=#net27}
N 9760 -12960 9920 -12960 {
lab=#net28}
N 9760 -12960 9760 -12810 {
lab=#net28}
N 9760 -12810 9760 -12370 {
lab=#net28}
N 9760 -12370 9920 -12370 {
lab=#net28}
N 12190 -13240 12210 -13240 {
lab=blb4}
N 12190 -13220 12220 -13220 {
lab=b4}
N 12960 -13330 12960 -13240 {
lab=q4}
N 13120 -13330 13120 -13240 {
lab=qb4}
N 13000 -13360 13000 -13210 {
lab=qb4}
N 13080 -13360 13080 -13210 {
lab=q4}
N 12960 -13420 12960 -13390 {
lab=VDD}
N 12960 -13420 13120 -13420 {
lab=VDD}
N 13120 -13420 13120 -13390 {
lab=VDD}
N 12960 -13180 12960 -13140 {
lab=GND}
N 12960 -13140 13120 -13140 {
lab=GND}
N 13120 -13180 13120 -13140 {
lab=GND}
N 13040 -13140 13040 -13120 {
lab=GND}
N 13040 -13440 13040 -13420 {
lab=VDD}
N 12810 -13260 12960 -13260 {
lab=q4}
N 13120 -13270 13240 -13270 {
lab=qb4}
N 13000 -13270 13120 -13270 {
lab=qb4}
N 12700 -13260 12750 -13260 {
lab=b4}
N 13300 -13270 13340 -13270 {
lab=blb4}
N 12780 -13480 12780 -13300 {
lab=WL}
N 12780 -13480 13270 -13480 {
lab=WL}
N 13270 -13480 13270 -13310 {
lab=WL}
N 12700 -13480 12780 -13480 {
lab=WL}
N 12960 -13260 13080 -13260 {
lab=q4}
N 13200 -13310 13200 -13270 {
lab=qb4}
N 12870 -13300 12870 -13260 {
lab=q4}
N 12220 -13220 12700 -13220 {
lab=b4}
N 12700 -13260 12700 -13220 {
lab=b4}
N 12210 -13240 12690 -13240 {
lab=blb4}
N 12690 -13240 12690 -13080 {
lab=blb4}
N 12690 -13080 13350 -13080 {
lab=blb4}
N 13350 -13270 13350 -13080 {
lab=blb4}
N 13340 -13270 13350 -13270 {
lab=blb4}
N 12280 -12810 12280 -12700 {
lab=blb4}
N 12200 -12840 12240 -12840 {
lab=d4}
N 12200 -12840 12200 -12670 {
lab=d4}
N 12200 -12670 12240 -12670 {
lab=d4}
N 12280 -12320 12280 -12280 {
lab=#net29}
N 12280 -12220 12280 -12110 {
lab=b4}
N 12280 -12050 12280 -12010 {
lab=#net30}
N 12200 -12250 12240 -12250 {
lab=#net31}
N 12200 -12250 12200 -12080 {
lab=#net31}
N 12200 -12080 12240 -12080 {
lab=#net31}
N 12030 -11980 12240 -11980 {
lab=we}
N 11960 -11980 12030 -11980 {
lab=we}
N 11960 -12780 11960 -11980 {
lab=we}
N 11960 -12790 11960 -12780 {
lab=we}
N 11960 -12790 12020 -12790 {
lab=we}
N 11960 -12570 12240 -12570 {
lab=we}
N 11970 -12760 11970 -12680 {
lab=d4}
N 11970 -12760 12200 -12760 {
lab=d4}
N 11970 -12690 11970 -12160 {
lab=d4}
N 11970 -12160 12000 -12160 {
lab=d4}
N 12060 -12160 12200 -12160 {
lab=#net31}
N 12280 -11950 12280 -11910 {
lab=GND}
N 12280 -12540 12280 -12500 {
lab=GND}
N 12280 -13010 12280 -12970 {
lab=VDD}
N 12280 -12400 12280 -12380 {
lab=VDD}
N 12280 -12760 12440 -12760 {
lab=blb4}
N 12280 -12170 12430 -12170 {
lab=b4}
N 12430 -12170 12440 -12170 {
lab=b4}
N 11880 -12790 11960 -12790 {
lab=we}
N 11880 -12160 11970 -12160 {
lab=d4}
N 12410 -13240 12410 -12760 {
lab=blb4}
N 12420 -13220 12420 -12170 {
lab=b4}
N 11870 -13370 11870 -13280 {
lab=b4}
N 11780 -13370 11870 -13370 {
lab=b4}
N 11870 -13220 11870 -13150 {
lab=blb4}
N 11780 -13150 11870 -13150 {
lab=blb4}
N 11680 -13150 11720 -13150 {
lab=VDD}
N 11680 -13370 11680 -13150 {
lab=VDD}
N 11680 -13370 11720 -13370 {
lab=VDD}
N 11830 -13250 11830 -13080 {
lab=p_b}
N 11680 -13150 11680 -13070 {
lab=VDD}
N 11870 -13370 11940 -13370 {
lab=b4}
N 11750 -13330 11750 -13190 {
lab=p_b}
N 11750 -13220 11830 -13220 {
lab=p_b}
N 12090 -13240 12190 -13240 {
lab=blb4}
N 12090 -13240 12090 -13160 {
lab=blb4}
N 11870 -13160 12090 -13160 {
lab=blb4}
N 11940 -13220 12190 -13220 {
lab=b4}
N 11940 -13370 11940 -13220 {
lab=b4}
N 13140 -12770 13230 -12770 {
lab=o4}
N 13230 -12860 13230 -12770 {
lab=o4}
N 13010 -12770 13080 -12770 {
lab=ob4}
N 13010 -12860 13010 -12770 {
lab=ob4}
N 13010 -12960 13010 -12920 {
lab=VDD}
N 13010 -12960 13230 -12960 {
lab=VDD}
N 13230 -12960 13230 -12920 {
lab=VDD}
N 12940 -12810 13110 -12810 {
lab=p_b}
N 12930 -12960 13010 -12960 {
lab=VDD}
N 12940 -12770 13010 -12770 {
lab=ob4}
N 13050 -12890 13190 -12890 {
lab=p_b}
N 13080 -12890 13080 -12810 {
lab=p_b}
N 13230 -12670 13230 -12650 {
lab=VDD}
N 13010 -12670 13230 -12670 {
lab=VDD}
N 13010 -12670 13010 -12660 {
lab=VDD}
N 13050 -12630 13150 -12630 {
lab=o4}
N 13150 -12630 13150 -12570 {
lab=o4}
N 13150 -12570 13230 -12570 {
lab=o4}
N 13230 -12590 13230 -12570 {
lab=o4}
N 13270 -12620 13300 -12620 {
lab=ob4}
N 13300 -12620 13300 -12550 {
lab=ob4}
N 13010 -12550 13300 -12550 {
lab=ob4}
N 13010 -12600 13010 -12550 {
lab=ob4}
N 13230 -12570 13230 -12490 {
lab=o4}
N 13010 -12550 13010 -12500 {
lab=ob4}
N 13010 -12440 13010 -12410 {
lab=#net32}
N 13010 -12410 13230 -12410 {
lab=#net32}
N 13230 -12430 13230 -12410 {
lab=#net32}
N 13100 -12410 13100 -12350 {
lab=#net32}
N 13100 -12290 13100 -12260 {
lab=GND}
N 12980 -12320 13060 -12320 {
lab=VDD}
N 12950 -12470 12970 -12470 {
lab=o4}
N 12950 -12570 12950 -12470 {
lab=o4}
N 12950 -12570 13070 -12570 {
lab=o4}
N 13070 -12630 13070 -12570 {
lab=o4}
N 13160 -12460 13190 -12460 {
lab=ob4}
N 13160 -12550 13160 -12460 {
lab=ob4}
N 12910 -12550 13010 -12550 {
lab=ob4}
N 12910 -12770 12910 -12550 {
lab=ob4}
N 12910 -12770 12950 -12770 {
lab=ob4}
N 13230 -12770 13340 -12770 {
lab=o4}
N 13340 -12770 13340 -12540 {
lab=o4}
N 13230 -12540 13340 -12540 {
lab=o4}
N 12790 -12550 12910 -12550 {
lab=ob4}
N 13340 -12540 13430 -12540 {
lab=o4}
N 12760 -12640 12760 -12590 {
lab=rd}
N 13460 -12620 13460 -12580 {
lab=rd}
N 13490 -12540 13560 -12540 {
lab=b4}
N 12670 -12550 12730 -12550 {
lab=blb4}
N 13380 -12610 13380 -12540 {
lab=o4}
N 12850 -12640 12850 -12550 {
lab=ob4}
N 12680 -13080 12680 -12550 {
lab=blb4}
N 12680 -13080 12690 -13080 {
lab=blb4}
N 13540 -13020 13540 -12540 {
lab=b4}
N 12700 -13020 13540 -13020 {
lab=b4}
N 12700 -13220 12700 -13020 {
lab=b4}
N 12520 -13250 12520 -13240 {
lab=blb4}
N 12480 -13250 12480 -13220 {
lab=b4}
N 12280 -12910 12280 -12870 {
lab=#net33}
N 12280 -12640 12280 -12600 {
lab=#net34}
N 12080 -12940 12240 -12940 {
lab=#net35}
N 12080 -12940 12080 -12790 {
lab=#net35}
N 12080 -12790 12080 -12350 {
lab=#net35}
N 12080 -12350 12240 -12350 {
lab=#net35}
N 14340 -13230 14360 -13230 {
lab=blb5}
N 14340 -13210 14370 -13210 {
lab=b5}
N 15110 -13320 15110 -13230 {
lab=q5}
N 15270 -13320 15270 -13230 {
lab=qb5}
N 15150 -13350 15150 -13200 {
lab=qb5}
N 15230 -13350 15230 -13200 {
lab=q5}
N 15110 -13410 15110 -13380 {
lab=VDD}
N 15110 -13410 15270 -13410 {
lab=VDD}
N 15270 -13410 15270 -13380 {
lab=VDD}
N 15110 -13170 15110 -13130 {
lab=GND}
N 15110 -13130 15270 -13130 {
lab=GND}
N 15270 -13170 15270 -13130 {
lab=GND}
N 15190 -13130 15190 -13110 {
lab=GND}
N 15190 -13430 15190 -13410 {
lab=VDD}
N 14960 -13250 15110 -13250 {
lab=q5}
N 15270 -13260 15390 -13260 {
lab=qb5}
N 15150 -13260 15270 -13260 {
lab=qb5}
N 14850 -13250 14900 -13250 {
lab=b5}
N 15450 -13260 15490 -13260 {
lab=blb5}
N 14930 -13470 14930 -13290 {
lab=WL}
N 14930 -13470 15420 -13470 {
lab=WL}
N 15420 -13470 15420 -13300 {
lab=WL}
N 14850 -13470 14930 -13470 {
lab=WL}
N 15110 -13250 15230 -13250 {
lab=q5}
N 15350 -13300 15350 -13260 {
lab=qb5}
N 15020 -13290 15020 -13250 {
lab=q5}
N 14370 -13210 14850 -13210 {
lab=b5}
N 14850 -13250 14850 -13210 {
lab=b5}
N 14360 -13230 14840 -13230 {
lab=blb5}
N 14840 -13230 14840 -13070 {
lab=blb5}
N 14840 -13070 15500 -13070 {
lab=blb5}
N 15500 -13260 15500 -13070 {
lab=blb5}
N 15490 -13260 15500 -13260 {
lab=blb5}
N 14430 -12800 14430 -12690 {
lab=blb5}
N 14350 -12830 14390 -12830 {
lab=d5}
N 14350 -12830 14350 -12660 {
lab=d5}
N 14350 -12660 14390 -12660 {
lab=d5}
N 14430 -12310 14430 -12270 {
lab=#net36}
N 14430 -12210 14430 -12100 {
lab=b5}
N 14430 -12040 14430 -12000 {
lab=#net37}
N 14350 -12240 14390 -12240 {
lab=#net38}
N 14350 -12240 14350 -12070 {
lab=#net38}
N 14350 -12070 14390 -12070 {
lab=#net38}
N 14180 -11970 14390 -11970 {
lab=we}
N 14110 -11970 14180 -11970 {
lab=we}
N 14110 -12770 14110 -11970 {
lab=we}
N 14110 -12780 14110 -12770 {
lab=we}
N 14110 -12780 14170 -12780 {
lab=we}
N 14110 -12560 14390 -12560 {
lab=we}
N 14120 -12750 14120 -12670 {
lab=d5}
N 14120 -12750 14350 -12750 {
lab=d5}
N 14120 -12680 14120 -12150 {
lab=d5}
N 14120 -12150 14150 -12150 {
lab=d5}
N 14210 -12150 14350 -12150 {
lab=#net38}
N 14430 -11940 14430 -11900 {
lab=GND}
N 14430 -12530 14430 -12490 {
lab=GND}
N 14430 -13000 14430 -12960 {
lab=VDD}
N 14430 -12390 14430 -12370 {
lab=VDD}
N 14430 -12750 14590 -12750 {
lab=blb5}
N 14430 -12160 14580 -12160 {
lab=b5}
N 14580 -12160 14590 -12160 {
lab=b5}
N 14030 -12780 14110 -12780 {
lab=we}
N 14030 -12150 14120 -12150 {
lab=d5}
N 14560 -13230 14560 -12750 {
lab=blb5}
N 14570 -13210 14570 -12160 {
lab=b5}
N 14020 -13360 14020 -13270 {
lab=b5}
N 13930 -13360 14020 -13360 {
lab=b5}
N 14020 -13210 14020 -13140 {
lab=blb5}
N 13930 -13140 14020 -13140 {
lab=blb5}
N 13830 -13140 13870 -13140 {
lab=VDD}
N 13830 -13360 13830 -13140 {
lab=VDD}
N 13830 -13360 13870 -13360 {
lab=VDD}
N 13980 -13240 13980 -13070 {
lab=p_b}
N 13830 -13140 13830 -13060 {
lab=VDD}
N 14020 -13360 14090 -13360 {
lab=b5}
N 13900 -13320 13900 -13180 {
lab=p_b}
N 13900 -13210 13980 -13210 {
lab=p_b}
N 14240 -13230 14340 -13230 {
lab=blb5}
N 14240 -13230 14240 -13150 {
lab=blb5}
N 14020 -13150 14240 -13150 {
lab=blb5}
N 14090 -13210 14340 -13210 {
lab=b5}
N 14090 -13360 14090 -13210 {
lab=b5}
N 15290 -12760 15380 -12760 {
lab=o5}
N 15380 -12850 15380 -12760 {
lab=o5}
N 15160 -12760 15230 -12760 {
lab=ob5}
N 15160 -12850 15160 -12760 {
lab=ob5}
N 15160 -12950 15160 -12910 {
lab=VDD}
N 15160 -12950 15380 -12950 {
lab=VDD}
N 15380 -12950 15380 -12910 {
lab=VDD}
N 15090 -12800 15260 -12800 {
lab=p_b}
N 15080 -12950 15160 -12950 {
lab=VDD}
N 15090 -12760 15160 -12760 {
lab=ob5}
N 15200 -12880 15340 -12880 {
lab=p_b}
N 15230 -12880 15230 -12800 {
lab=p_b}
N 15380 -12660 15380 -12640 {
lab=VDD}
N 15160 -12660 15380 -12660 {
lab=VDD}
N 15160 -12660 15160 -12650 {
lab=VDD}
N 15200 -12620 15300 -12620 {
lab=o5}
N 15300 -12620 15300 -12560 {
lab=o5}
N 15300 -12560 15380 -12560 {
lab=o5}
N 15380 -12580 15380 -12560 {
lab=o5}
N 15420 -12610 15450 -12610 {
lab=ob5}
N 15450 -12610 15450 -12540 {
lab=ob5}
N 15160 -12540 15450 -12540 {
lab=ob5}
N 15160 -12590 15160 -12540 {
lab=ob5}
N 15380 -12560 15380 -12480 {
lab=o5}
N 15160 -12540 15160 -12490 {
lab=ob5}
N 15160 -12430 15160 -12400 {
lab=#net39}
N 15160 -12400 15380 -12400 {
lab=#net39}
N 15380 -12420 15380 -12400 {
lab=#net39}
N 15250 -12400 15250 -12340 {
lab=#net39}
N 15250 -12280 15250 -12250 {
lab=GND}
N 15130 -12310 15210 -12310 {
lab=VDD}
N 15100 -12460 15120 -12460 {
lab=o5}
N 15100 -12560 15100 -12460 {
lab=o5}
N 15100 -12560 15220 -12560 {
lab=o5}
N 15220 -12620 15220 -12560 {
lab=o5}
N 15310 -12450 15340 -12450 {
lab=ob5}
N 15310 -12540 15310 -12450 {
lab=ob5}
N 15060 -12540 15160 -12540 {
lab=ob5}
N 15060 -12760 15060 -12540 {
lab=ob5}
N 15060 -12760 15100 -12760 {
lab=ob5}
N 15380 -12760 15490 -12760 {
lab=o5}
N 15490 -12760 15490 -12530 {
lab=o5}
N 15380 -12530 15490 -12530 {
lab=o5}
N 14940 -12540 15060 -12540 {
lab=ob5}
N 15490 -12530 15580 -12530 {
lab=o5}
N 14910 -12630 14910 -12580 {
lab=rd}
N 15610 -12610 15610 -12570 {
lab=rd}
N 15640 -12530 15710 -12530 {
lab=b5}
N 14820 -12540 14880 -12540 {
lab=blb5}
N 15530 -12600 15530 -12530 {
lab=o5}
N 15000 -12630 15000 -12540 {
lab=ob5}
N 14830 -13070 14830 -12540 {
lab=blb5}
N 14830 -13070 14840 -13070 {
lab=blb5}
N 15690 -13010 15690 -12530 {
lab=b5}
N 14850 -13010 15690 -13010 {
lab=b5}
N 14850 -13210 14850 -13010 {
lab=b5}
N 14670 -13240 14670 -13230 {
lab=blb5}
N 14630 -13240 14630 -13210 {
lab=b5}
N 14430 -12900 14430 -12860 {
lab=#net40}
N 14430 -12630 14430 -12590 {
lab=#net41}
N 14230 -12930 14390 -12930 {
lab=#net42}
N 14230 -12930 14230 -12780 {
lab=#net42}
N 14230 -12780 14230 -12340 {
lab=#net42}
N 14230 -12340 14390 -12340 {
lab=#net42}
N 3610 -11050 3630 -11050 {
lab=blb6}
N 3610 -11030 3640 -11030 {
lab=b6}
N 4380 -11140 4380 -11050 {
lab=q6}
N 4540 -11140 4540 -11050 {
lab=qb6}
N 4420 -11170 4420 -11020 {
lab=qb6}
N 4500 -11170 4500 -11020 {
lab=q6}
N 4380 -11230 4380 -11200 {
lab=VDD}
N 4380 -11230 4540 -11230 {
lab=VDD}
N 4540 -11230 4540 -11200 {
lab=VDD}
N 4380 -10990 4380 -10950 {
lab=GND}
N 4380 -10950 4540 -10950 {
lab=GND}
N 4540 -10990 4540 -10950 {
lab=GND}
N 4460 -10950 4460 -10930 {
lab=GND}
N 4460 -11250 4460 -11230 {
lab=VDD}
N 4230 -11070 4380 -11070 {
lab=q6}
N 4540 -11080 4660 -11080 {
lab=qb6}
N 4420 -11080 4540 -11080 {
lab=qb6}
N 4120 -11070 4170 -11070 {
lab=b6}
N 4720 -11080 4760 -11080 {
lab=blb6}
N 4200 -11290 4200 -11110 {
lab=WL}
N 4200 -11290 4690 -11290 {
lab=WL}
N 4690 -11290 4690 -11120 {
lab=WL}
N 4120 -11290 4200 -11290 {
lab=WL}
N 4380 -11070 4500 -11070 {
lab=q6}
N 4620 -11120 4620 -11080 {
lab=qb6}
N 4290 -11110 4290 -11070 {
lab=q6}
N 3640 -11030 4120 -11030 {
lab=b6}
N 4120 -11070 4120 -11030 {
lab=b6}
N 3630 -11050 4110 -11050 {
lab=blb6}
N 4110 -11050 4110 -10890 {
lab=blb6}
N 4110 -10890 4770 -10890 {
lab=blb6}
N 4770 -11080 4770 -10890 {
lab=blb6}
N 4760 -11080 4770 -11080 {
lab=blb6}
N 3700 -10620 3700 -10510 {
lab=blb6}
N 3620 -10650 3660 -10650 {
lab=d6}
N 3620 -10650 3620 -10480 {
lab=d6}
N 3620 -10480 3660 -10480 {
lab=d6}
N 3700 -10130 3700 -10090 {
lab=#net43}
N 3700 -10030 3700 -9920 {
lab=b6}
N 3700 -9860 3700 -9820 {
lab=#net44}
N 3620 -10060 3660 -10060 {
lab=#net45}
N 3620 -10060 3620 -9890 {
lab=#net45}
N 3620 -9890 3660 -9890 {
lab=#net45}
N 3450 -9790 3660 -9790 {
lab=we}
N 3380 -9790 3450 -9790 {
lab=we}
N 3380 -10590 3380 -9790 {
lab=we}
N 3380 -10600 3380 -10590 {
lab=we}
N 3380 -10600 3440 -10600 {
lab=we}
N 3380 -10380 3660 -10380 {
lab=we}
N 3390 -10570 3390 -10490 {
lab=d6}
N 3390 -10570 3620 -10570 {
lab=d6}
N 3390 -10500 3390 -9970 {
lab=d6}
N 3390 -9970 3420 -9970 {
lab=d6}
N 3480 -9970 3620 -9970 {
lab=#net45}
N 3700 -9760 3700 -9720 {
lab=GND}
N 3700 -10350 3700 -10310 {
lab=GND}
N 3700 -10820 3700 -10780 {
lab=VDD}
N 3700 -10210 3700 -10190 {
lab=VDD}
N 3700 -10570 3860 -10570 {
lab=blb6}
N 3700 -9980 3850 -9980 {
lab=b6}
N 3850 -9980 3860 -9980 {
lab=b6}
N 3300 -10600 3380 -10600 {
lab=we}
N 3300 -9970 3390 -9970 {
lab=d6}
N 3830 -11050 3830 -10570 {
lab=blb6}
N 3840 -11030 3840 -9980 {
lab=b6}
N 3290 -11180 3290 -11090 {
lab=b6}
N 3200 -11180 3290 -11180 {
lab=b6}
N 3290 -11030 3290 -10960 {
lab=blb6}
N 3200 -10960 3290 -10960 {
lab=blb6}
N 3100 -10960 3140 -10960 {
lab=VDD}
N 3100 -11180 3100 -10960 {
lab=VDD}
N 3100 -11180 3140 -11180 {
lab=VDD}
N 3250 -11060 3250 -10890 {
lab=p_b}
N 3100 -10960 3100 -10880 {
lab=VDD}
N 3290 -11180 3360 -11180 {
lab=b6}
N 3170 -11140 3170 -11000 {
lab=p_b}
N 3170 -11030 3250 -11030 {
lab=p_b}
N 3510 -11050 3610 -11050 {
lab=blb6}
N 3510 -11050 3510 -10970 {
lab=blb6}
N 3290 -10970 3510 -10970 {
lab=blb6}
N 3360 -11030 3610 -11030 {
lab=b6}
N 3360 -11180 3360 -11030 {
lab=b6}
N 4560 -10580 4650 -10580 {
lab=o6}
N 4650 -10670 4650 -10580 {
lab=o6}
N 4430 -10580 4500 -10580 {
lab=ob6}
N 4430 -10670 4430 -10580 {
lab=ob6}
N 4430 -10770 4430 -10730 {
lab=VDD}
N 4430 -10770 4650 -10770 {
lab=VDD}
N 4650 -10770 4650 -10730 {
lab=VDD}
N 4360 -10620 4530 -10620 {
lab=p_b}
N 4350 -10770 4430 -10770 {
lab=VDD}
N 4360 -10580 4430 -10580 {
lab=ob6}
N 4470 -10700 4610 -10700 {
lab=p_b}
N 4500 -10700 4500 -10620 {
lab=p_b}
N 4650 -10480 4650 -10460 {
lab=VDD}
N 4430 -10480 4650 -10480 {
lab=VDD}
N 4430 -10480 4430 -10470 {
lab=VDD}
N 4470 -10440 4570 -10440 {
lab=o6}
N 4570 -10440 4570 -10380 {
lab=o6}
N 4570 -10380 4650 -10380 {
lab=o6}
N 4650 -10400 4650 -10380 {
lab=o6}
N 4690 -10430 4720 -10430 {
lab=ob6}
N 4720 -10430 4720 -10360 {
lab=ob6}
N 4430 -10360 4720 -10360 {
lab=ob6}
N 4430 -10410 4430 -10360 {
lab=ob6}
N 4650 -10380 4650 -10300 {
lab=o6}
N 4430 -10360 4430 -10310 {
lab=ob6}
N 4430 -10250 4430 -10220 {
lab=#net46}
N 4430 -10220 4650 -10220 {
lab=#net46}
N 4650 -10240 4650 -10220 {
lab=#net46}
N 4520 -10220 4520 -10160 {
lab=#net46}
N 4520 -10100 4520 -10070 {
lab=GND}
N 4400 -10130 4480 -10130 {
lab=VDD}
N 4370 -10280 4390 -10280 {
lab=o6}
N 4370 -10380 4370 -10280 {
lab=o6}
N 4370 -10380 4490 -10380 {
lab=o6}
N 4490 -10440 4490 -10380 {
lab=o6}
N 4580 -10270 4610 -10270 {
lab=ob6}
N 4580 -10360 4580 -10270 {
lab=ob6}
N 4330 -10360 4430 -10360 {
lab=ob6}
N 4330 -10580 4330 -10360 {
lab=ob6}
N 4330 -10580 4370 -10580 {
lab=ob6}
N 4650 -10580 4760 -10580 {
lab=o6}
N 4760 -10580 4760 -10350 {
lab=o6}
N 4650 -10350 4760 -10350 {
lab=o6}
N 4210 -10360 4330 -10360 {
lab=ob6}
N 4760 -10350 4850 -10350 {
lab=o6}
N 4180 -10450 4180 -10400 {
lab=rd}
N 4880 -10430 4880 -10390 {
lab=rd}
N 4910 -10350 4980 -10350 {
lab=b6}
N 4090 -10360 4150 -10360 {
lab=blb6}
N 4800 -10420 4800 -10350 {
lab=o6}
N 4270 -10450 4270 -10360 {
lab=ob6}
N 4100 -10890 4100 -10360 {
lab=blb6}
N 4100 -10890 4110 -10890 {
lab=blb6}
N 4960 -10830 4960 -10350 {
lab=b6}
N 4120 -10830 4960 -10830 {
lab=b6}
N 4120 -11030 4120 -10830 {
lab=b6}
N 3940 -11060 3940 -11050 {
lab=blb6}
N 3900 -11060 3900 -11030 {
lab=b6}
N 3700 -10720 3700 -10680 {
lab=#net47}
N 3700 -10450 3700 -10410 {
lab=#net48}
N 3500 -10750 3660 -10750 {
lab=#net49}
N 3500 -10750 3500 -10600 {
lab=#net49}
N 3500 -10600 3500 -10160 {
lab=#net49}
N 3500 -10160 3660 -10160 {
lab=#net49}
N 5930 -11030 5950 -11030 {
lab=blb7}
N 5930 -11010 5960 -11010 {
lab=b7}
N 6700 -11120 6700 -11030 {
lab=q7}
N 6860 -11120 6860 -11030 {
lab=qb7}
N 6740 -11150 6740 -11000 {
lab=qb7}
N 6820 -11150 6820 -11000 {
lab=q7}
N 6700 -11210 6700 -11180 {
lab=VDD}
N 6700 -11210 6860 -11210 {
lab=VDD}
N 6860 -11210 6860 -11180 {
lab=VDD}
N 6700 -10970 6700 -10930 {
lab=GND}
N 6700 -10930 6860 -10930 {
lab=GND}
N 6860 -10970 6860 -10930 {
lab=GND}
N 6780 -10930 6780 -10910 {
lab=GND}
N 6780 -11230 6780 -11210 {
lab=VDD}
N 6550 -11050 6700 -11050 {
lab=q7}
N 6860 -11060 6980 -11060 {
lab=qb7}
N 6740 -11060 6860 -11060 {
lab=qb7}
N 6440 -11050 6490 -11050 {
lab=b7}
N 7040 -11060 7080 -11060 {
lab=blb7}
N 6520 -11270 6520 -11090 {
lab=WL}
N 6520 -11270 7010 -11270 {
lab=WL}
N 7010 -11270 7010 -11100 {
lab=WL}
N 6440 -11270 6520 -11270 {
lab=WL}
N 6700 -11050 6820 -11050 {
lab=q7}
N 6940 -11100 6940 -11060 {
lab=qb7}
N 6610 -11090 6610 -11050 {
lab=q7}
N 5960 -11010 6440 -11010 {
lab=b7}
N 6440 -11050 6440 -11010 {
lab=b7}
N 5950 -11030 6430 -11030 {
lab=blb7}
N 6430 -11030 6430 -10870 {
lab=blb7}
N 6430 -10870 7090 -10870 {
lab=blb7}
N 7090 -11060 7090 -10870 {
lab=blb7}
N 7080 -11060 7090 -11060 {
lab=blb7}
N 6020 -10600 6020 -10490 {
lab=blb7}
N 5940 -10630 5980 -10630 {
lab=d7}
N 5940 -10630 5940 -10460 {
lab=d7}
N 5940 -10460 5980 -10460 {
lab=d7}
N 6020 -10110 6020 -10070 {
lab=#net50}
N 6020 -10010 6020 -9900 {
lab=b7}
N 6020 -9840 6020 -9800 {
lab=#net51}
N 5940 -10040 5980 -10040 {
lab=#net52}
N 5940 -10040 5940 -9870 {
lab=#net52}
N 5940 -9870 5980 -9870 {
lab=#net52}
N 5770 -9770 5980 -9770 {
lab=we}
N 5700 -9770 5770 -9770 {
lab=we}
N 5700 -10570 5700 -9770 {
lab=we}
N 5700 -10580 5700 -10570 {
lab=we}
N 5700 -10580 5760 -10580 {
lab=we}
N 5700 -10360 5980 -10360 {
lab=we}
N 5710 -10550 5710 -10470 {
lab=d7}
N 5710 -10550 5940 -10550 {
lab=d7}
N 5710 -10480 5710 -9950 {
lab=d7}
N 5710 -9950 5740 -9950 {
lab=d7}
N 5800 -9950 5940 -9950 {
lab=#net52}
N 6020 -9740 6020 -9700 {
lab=GND}
N 6020 -10330 6020 -10290 {
lab=GND}
N 6020 -10800 6020 -10760 {
lab=VDD}
N 6020 -10190 6020 -10170 {
lab=VDD}
N 6020 -10550 6180 -10550 {
lab=blb7}
N 6020 -9960 6170 -9960 {
lab=b7}
N 6170 -9960 6180 -9960 {
lab=b7}
N 5620 -10580 5700 -10580 {
lab=we}
N 5620 -9950 5710 -9950 {
lab=d7}
N 6150 -11030 6150 -10550 {
lab=blb7}
N 6160 -11010 6160 -9960 {
lab=b7}
N 5610 -11160 5610 -11070 {
lab=b7}
N 5520 -11160 5610 -11160 {
lab=b7}
N 5610 -11010 5610 -10940 {
lab=blb7}
N 5520 -10940 5610 -10940 {
lab=blb7}
N 5420 -10940 5460 -10940 {
lab=VDD}
N 5420 -11160 5420 -10940 {
lab=VDD}
N 5420 -11160 5460 -11160 {
lab=VDD}
N 5570 -11040 5570 -10870 {
lab=p_b}
N 5420 -10940 5420 -10860 {
lab=VDD}
N 5610 -11160 5680 -11160 {
lab=b7}
N 5490 -11120 5490 -10980 {
lab=p_b}
N 5490 -11010 5570 -11010 {
lab=p_b}
N 5830 -11030 5930 -11030 {
lab=blb7}
N 5830 -11030 5830 -10950 {
lab=blb7}
N 5610 -10950 5830 -10950 {
lab=blb7}
N 5680 -11010 5930 -11010 {
lab=b7}
N 5680 -11160 5680 -11010 {
lab=b7}
N 6880 -10560 6970 -10560 {
lab=o7}
N 6970 -10650 6970 -10560 {
lab=o7}
N 6750 -10560 6820 -10560 {
lab=ob7}
N 6750 -10650 6750 -10560 {
lab=ob7}
N 6750 -10750 6750 -10710 {
lab=VDD}
N 6750 -10750 6970 -10750 {
lab=VDD}
N 6970 -10750 6970 -10710 {
lab=VDD}
N 6680 -10600 6850 -10600 {
lab=p_b}
N 6670 -10750 6750 -10750 {
lab=VDD}
N 6680 -10560 6750 -10560 {
lab=ob7}
N 6790 -10680 6930 -10680 {
lab=p_b}
N 6820 -10680 6820 -10600 {
lab=p_b}
N 6970 -10460 6970 -10440 {
lab=VDD}
N 6750 -10460 6970 -10460 {
lab=VDD}
N 6750 -10460 6750 -10450 {
lab=VDD}
N 6790 -10420 6890 -10420 {
lab=o7}
N 6890 -10420 6890 -10360 {
lab=o7}
N 6890 -10360 6970 -10360 {
lab=o7}
N 6970 -10380 6970 -10360 {
lab=o7}
N 7010 -10410 7040 -10410 {
lab=ob7}
N 7040 -10410 7040 -10340 {
lab=ob7}
N 6750 -10340 7040 -10340 {
lab=ob7}
N 6750 -10390 6750 -10340 {
lab=ob7}
N 6970 -10360 6970 -10280 {
lab=o7}
N 6750 -10340 6750 -10290 {
lab=ob7}
N 6750 -10230 6750 -10200 {
lab=#net53}
N 6750 -10200 6970 -10200 {
lab=#net53}
N 6970 -10220 6970 -10200 {
lab=#net53}
N 6840 -10200 6840 -10140 {
lab=#net53}
N 6840 -10080 6840 -10050 {
lab=GND}
N 6720 -10110 6800 -10110 {
lab=VDD}
N 6690 -10260 6710 -10260 {
lab=o7}
N 6690 -10360 6690 -10260 {
lab=o7}
N 6690 -10360 6810 -10360 {
lab=o7}
N 6810 -10420 6810 -10360 {
lab=o7}
N 6900 -10250 6930 -10250 {
lab=ob7}
N 6900 -10340 6900 -10250 {
lab=ob7}
N 6650 -10340 6750 -10340 {
lab=ob7}
N 6650 -10560 6650 -10340 {
lab=ob7}
N 6650 -10560 6690 -10560 {
lab=ob7}
N 6970 -10560 7080 -10560 {
lab=o7}
N 7080 -10560 7080 -10330 {
lab=o7}
N 6970 -10330 7080 -10330 {
lab=o7}
N 6530 -10340 6650 -10340 {
lab=ob7}
N 7080 -10330 7170 -10330 {
lab=o7}
N 6500 -10430 6500 -10380 {
lab=rd}
N 7200 -10410 7200 -10370 {
lab=rd}
N 7230 -10330 7300 -10330 {
lab=b7}
N 6410 -10340 6470 -10340 {
lab=blb7}
N 7120 -10400 7120 -10330 {
lab=o7}
N 6590 -10430 6590 -10340 {
lab=ob7}
N 6420 -10870 6420 -10340 {
lab=blb7}
N 6420 -10870 6430 -10870 {
lab=blb7}
N 7280 -10810 7280 -10330 {
lab=b7}
N 6440 -10810 7280 -10810 {
lab=b7}
N 6440 -11010 6440 -10810 {
lab=b7}
N 6260 -11040 6260 -11030 {
lab=blb7}
N 6220 -11040 6220 -11010 {
lab=b7}
N 6020 -10700 6020 -10660 {
lab=#net54}
N 6020 -10430 6020 -10390 {
lab=#net55}
N 5820 -10730 5980 -10730 {
lab=#net56}
N 5820 -10730 5820 -10580 {
lab=#net56}
N 5820 -10580 5820 -10140 {
lab=#net56}
N 5820 -10140 5980 -10140 {
lab=#net56}
N 8080 -11020 8100 -11020 {
lab=blb8}
N 8080 -11000 8110 -11000 {
lab=b8}
N 8850 -11110 8850 -11020 {
lab=q8}
N 9010 -11110 9010 -11020 {
lab=qb8}
N 8890 -11140 8890 -10990 {
lab=qb8}
N 8970 -11140 8970 -10990 {
lab=q8}
N 8850 -11200 8850 -11170 {
lab=VDD}
N 8850 -11200 9010 -11200 {
lab=VDD}
N 9010 -11200 9010 -11170 {
lab=VDD}
N 8850 -10960 8850 -10920 {
lab=GND}
N 8850 -10920 9010 -10920 {
lab=GND}
N 9010 -10960 9010 -10920 {
lab=GND}
N 8930 -10920 8930 -10900 {
lab=GND}
N 8930 -11220 8930 -11200 {
lab=VDD}
N 8700 -11040 8850 -11040 {
lab=q8}
N 9010 -11050 9130 -11050 {
lab=qb8}
N 8890 -11050 9010 -11050 {
lab=qb8}
N 8590 -11040 8640 -11040 {
lab=b8}
N 9190 -11050 9230 -11050 {
lab=blb8}
N 8670 -11260 8670 -11080 {
lab=WL}
N 8670 -11260 9160 -11260 {
lab=WL}
N 9160 -11260 9160 -11090 {
lab=WL}
N 8590 -11260 8670 -11260 {
lab=WL}
N 8850 -11040 8970 -11040 {
lab=q8}
N 9090 -11090 9090 -11050 {
lab=qb8}
N 8760 -11080 8760 -11040 {
lab=q8}
N 8110 -11000 8590 -11000 {
lab=b8}
N 8590 -11040 8590 -11000 {
lab=b8}
N 8100 -11020 8580 -11020 {
lab=blb8}
N 8580 -11020 8580 -10860 {
lab=blb8}
N 8580 -10860 9240 -10860 {
lab=blb8}
N 9240 -11050 9240 -10860 {
lab=blb8}
N 9230 -11050 9240 -11050 {
lab=blb8}
N 8170 -10590 8170 -10480 {
lab=blb8}
N 8090 -10620 8130 -10620 {
lab=d8}
N 8090 -10620 8090 -10450 {
lab=d8}
N 8090 -10450 8130 -10450 {
lab=d8}
N 8170 -10100 8170 -10060 {
lab=#net57}
N 8170 -10000 8170 -9890 {
lab=b8}
N 8170 -9830 8170 -9790 {
lab=#net58}
N 8090 -10030 8130 -10030 {
lab=#net59}
N 8090 -10030 8090 -9860 {
lab=#net59}
N 8090 -9860 8130 -9860 {
lab=#net59}
N 7920 -9760 8130 -9760 {
lab=we}
N 7850 -9760 7920 -9760 {
lab=we}
N 7850 -10560 7850 -9760 {
lab=we}
N 7850 -10570 7850 -10560 {
lab=we}
N 7850 -10570 7910 -10570 {
lab=we}
N 7850 -10350 8130 -10350 {
lab=we}
N 7860 -10540 7860 -10460 {
lab=d8}
N 7860 -10540 8090 -10540 {
lab=d8}
N 7860 -10470 7860 -9940 {
lab=d8}
N 7860 -9940 7890 -9940 {
lab=d8}
N 7950 -9940 8090 -9940 {
lab=#net59}
N 8170 -9730 8170 -9690 {
lab=GND}
N 8170 -10320 8170 -10280 {
lab=GND}
N 8170 -10790 8170 -10750 {
lab=VDD}
N 8170 -10180 8170 -10160 {
lab=VDD}
N 8170 -10540 8330 -10540 {
lab=blb8}
N 8170 -9950 8320 -9950 {
lab=b8}
N 8320 -9950 8330 -9950 {
lab=b8}
N 7770 -10570 7850 -10570 {
lab=we}
N 7770 -9940 7860 -9940 {
lab=d8}
N 8300 -11020 8300 -10540 {
lab=blb8}
N 8310 -11000 8310 -9950 {
lab=b8}
N 7760 -11150 7760 -11060 {
lab=b8}
N 7670 -11150 7760 -11150 {
lab=b8}
N 7760 -11000 7760 -10930 {
lab=blb8}
N 7670 -10930 7760 -10930 {
lab=blb8}
N 7570 -10930 7610 -10930 {
lab=VDD}
N 7570 -11150 7570 -10930 {
lab=VDD}
N 7570 -11150 7610 -11150 {
lab=VDD}
N 7720 -11030 7720 -10860 {
lab=p_b}
N 7570 -10930 7570 -10850 {
lab=VDD}
N 7760 -11150 7830 -11150 {
lab=b8}
N 7640 -11110 7640 -10970 {
lab=p_b}
N 7640 -11000 7720 -11000 {
lab=p_b}
N 7980 -11020 8080 -11020 {
lab=blb8}
N 7980 -11020 7980 -10940 {
lab=blb8}
N 7760 -10940 7980 -10940 {
lab=blb8}
N 7830 -11000 8080 -11000 {
lab=b8}
N 7830 -11150 7830 -11000 {
lab=b8}
N 9030 -10550 9120 -10550 {
lab=o8}
N 9120 -10640 9120 -10550 {
lab=o8}
N 8900 -10550 8970 -10550 {
lab=ob8}
N 8900 -10640 8900 -10550 {
lab=ob8}
N 8900 -10740 8900 -10700 {
lab=VDD}
N 8900 -10740 9120 -10740 {
lab=VDD}
N 9120 -10740 9120 -10700 {
lab=VDD}
N 8830 -10590 9000 -10590 {
lab=p_b}
N 8820 -10740 8900 -10740 {
lab=VDD}
N 8830 -10550 8900 -10550 {
lab=ob8}
N 8940 -10670 9080 -10670 {
lab=p_b}
N 8970 -10670 8970 -10590 {
lab=p_b}
N 9120 -10450 9120 -10430 {
lab=VDD}
N 8900 -10450 9120 -10450 {
lab=VDD}
N 8900 -10450 8900 -10440 {
lab=VDD}
N 8940 -10410 9040 -10410 {
lab=o8}
N 9040 -10410 9040 -10350 {
lab=o8}
N 9040 -10350 9120 -10350 {
lab=o8}
N 9120 -10370 9120 -10350 {
lab=o8}
N 9160 -10400 9190 -10400 {
lab=ob8}
N 9190 -10400 9190 -10330 {
lab=ob8}
N 8900 -10330 9190 -10330 {
lab=ob8}
N 8900 -10380 8900 -10330 {
lab=ob8}
N 9120 -10350 9120 -10270 {
lab=o8}
N 8900 -10330 8900 -10280 {
lab=ob8}
N 8900 -10220 8900 -10190 {
lab=#net60}
N 8900 -10190 9120 -10190 {
lab=#net60}
N 9120 -10210 9120 -10190 {
lab=#net60}
N 8990 -10190 8990 -10130 {
lab=#net60}
N 8990 -10070 8990 -10040 {
lab=GND}
N 8870 -10100 8950 -10100 {
lab=VDD}
N 8840 -10250 8860 -10250 {
lab=o8}
N 8840 -10350 8840 -10250 {
lab=o8}
N 8840 -10350 8960 -10350 {
lab=o8}
N 8960 -10410 8960 -10350 {
lab=o8}
N 9050 -10240 9080 -10240 {
lab=ob8}
N 9050 -10330 9050 -10240 {
lab=ob8}
N 8800 -10330 8900 -10330 {
lab=ob8}
N 8800 -10550 8800 -10330 {
lab=ob8}
N 8800 -10550 8840 -10550 {
lab=ob8}
N 9120 -10550 9230 -10550 {
lab=o8}
N 9230 -10550 9230 -10320 {
lab=o8}
N 9120 -10320 9230 -10320 {
lab=o8}
N 8680 -10330 8800 -10330 {
lab=ob8}
N 9230 -10320 9320 -10320 {
lab=o8}
N 8650 -10420 8650 -10370 {
lab=rd}
N 9350 -10400 9350 -10360 {
lab=rd}
N 9380 -10320 9450 -10320 {
lab=b8}
N 8560 -10330 8620 -10330 {
lab=blb8}
N 9270 -10390 9270 -10320 {
lab=o8}
N 8740 -10420 8740 -10330 {
lab=ob8}
N 8570 -10860 8570 -10330 {
lab=blb8}
N 8570 -10860 8580 -10860 {
lab=blb8}
N 9430 -10800 9430 -10320 {
lab=b8}
N 8590 -10800 9430 -10800 {
lab=b8}
N 8590 -11000 8590 -10800 {
lab=b8}
N 8410 -11030 8410 -11020 {
lab=blb8}
N 8370 -11030 8370 -11000 {
lab=b8}
N 8170 -10690 8170 -10650 {
lab=#net61}
N 8170 -10420 8170 -10380 {
lab=#net62}
N 7970 -10720 8130 -10720 {
lab=#net63}
N 7970 -10720 7970 -10570 {
lab=#net63}
N 7970 -10570 7970 -10130 {
lab=#net63}
N 7970 -10130 8130 -10130 {
lab=#net63}
N 10210 -11020 10230 -11020 {
lab=blb9}
N 10210 -11000 10240 -11000 {
lab=b9}
N 10980 -11110 10980 -11020 {
lab=q9}
N 11140 -11110 11140 -11020 {
lab=qb9}
N 11020 -11140 11020 -10990 {
lab=qb9}
N 11100 -11140 11100 -10990 {
lab=q9}
N 10980 -11200 10980 -11170 {
lab=VDD}
N 10980 -11200 11140 -11200 {
lab=VDD}
N 11140 -11200 11140 -11170 {
lab=VDD}
N 10980 -10960 10980 -10920 {
lab=GND}
N 10980 -10920 11140 -10920 {
lab=GND}
N 11140 -10960 11140 -10920 {
lab=GND}
N 11060 -10920 11060 -10900 {
lab=GND}
N 11060 -11220 11060 -11200 {
lab=VDD}
N 10830 -11040 10980 -11040 {
lab=q9}
N 11140 -11050 11260 -11050 {
lab=qb9}
N 11020 -11050 11140 -11050 {
lab=qb9}
N 10720 -11040 10770 -11040 {
lab=b9}
N 11320 -11050 11360 -11050 {
lab=blb9}
N 10800 -11260 10800 -11080 {
lab=WL}
N 10800 -11260 11290 -11260 {
lab=WL}
N 11290 -11260 11290 -11090 {
lab=WL}
N 10720 -11260 10800 -11260 {
lab=WL}
N 10980 -11040 11100 -11040 {
lab=q9}
N 11220 -11090 11220 -11050 {
lab=qb9}
N 10890 -11080 10890 -11040 {
lab=q9}
N 10240 -11000 10720 -11000 {
lab=b9}
N 10720 -11040 10720 -11000 {
lab=b9}
N 10230 -11020 10710 -11020 {
lab=blb9}
N 10710 -11020 10710 -10860 {
lab=blb9}
N 10710 -10860 11370 -10860 {
lab=blb9}
N 11370 -11050 11370 -10860 {
lab=blb9}
N 11360 -11050 11370 -11050 {
lab=blb9}
N 10300 -10590 10300 -10480 {
lab=blb9}
N 10220 -10620 10260 -10620 {
lab=d9}
N 10220 -10620 10220 -10450 {
lab=d9}
N 10220 -10450 10260 -10450 {
lab=d9}
N 10300 -10100 10300 -10060 {
lab=#net64}
N 10300 -10000 10300 -9890 {
lab=b9}
N 10300 -9830 10300 -9790 {
lab=#net65}
N 10220 -10030 10260 -10030 {
lab=#net66}
N 10220 -10030 10220 -9860 {
lab=#net66}
N 10220 -9860 10260 -9860 {
lab=#net66}
N 10050 -9760 10260 -9760 {
lab=we}
N 9980 -9760 10050 -9760 {
lab=we}
N 9980 -10560 9980 -9760 {
lab=we}
N 9980 -10570 9980 -10560 {
lab=we}
N 9980 -10570 10040 -10570 {
lab=we}
N 9980 -10350 10260 -10350 {
lab=we}
N 9990 -10540 9990 -10460 {
lab=d9}
N 9990 -10540 10220 -10540 {
lab=d9}
N 9990 -10470 9990 -9940 {
lab=d9}
N 9990 -9940 10020 -9940 {
lab=d9}
N 10080 -9940 10220 -9940 {
lab=#net66}
N 10300 -9730 10300 -9690 {
lab=GND}
N 10300 -10320 10300 -10280 {
lab=GND}
N 10300 -10790 10300 -10750 {
lab=VDD}
N 10300 -10180 10300 -10160 {
lab=VDD}
N 10300 -10540 10460 -10540 {
lab=blb9}
N 10300 -9950 10450 -9950 {
lab=b9}
N 10450 -9950 10460 -9950 {
lab=b9}
N 9900 -10570 9980 -10570 {
lab=we}
N 9900 -9940 9990 -9940 {
lab=d9}
N 10430 -11020 10430 -10540 {
lab=blb9}
N 10440 -11000 10440 -9950 {
lab=b9}
N 9890 -11150 9890 -11060 {
lab=b9}
N 9800 -11150 9890 -11150 {
lab=b9}
N 9890 -11000 9890 -10930 {
lab=blb9}
N 9800 -10930 9890 -10930 {
lab=blb9}
N 9700 -10930 9740 -10930 {
lab=VDD}
N 9700 -11150 9700 -10930 {
lab=VDD}
N 9700 -11150 9740 -11150 {
lab=VDD}
N 9850 -11030 9850 -10860 {
lab=p_b}
N 9700 -10930 9700 -10850 {
lab=VDD}
N 9890 -11150 9960 -11150 {
lab=b9}
N 9770 -11110 9770 -10970 {
lab=p_b}
N 9770 -11000 9850 -11000 {
lab=p_b}
N 10110 -11020 10210 -11020 {
lab=blb9}
N 10110 -11020 10110 -10940 {
lab=blb9}
N 9890 -10940 10110 -10940 {
lab=blb9}
N 9960 -11000 10210 -11000 {
lab=b9}
N 9960 -11150 9960 -11000 {
lab=b9}
N 11160 -10550 11250 -10550 {
lab=o9}
N 11250 -10640 11250 -10550 {
lab=o9}
N 11030 -10550 11100 -10550 {
lab=ob9}
N 11030 -10640 11030 -10550 {
lab=ob9}
N 11030 -10740 11030 -10700 {
lab=VDD}
N 11030 -10740 11250 -10740 {
lab=VDD}
N 11250 -10740 11250 -10700 {
lab=VDD}
N 10960 -10590 11130 -10590 {
lab=p_b}
N 10950 -10740 11030 -10740 {
lab=VDD}
N 10960 -10550 11030 -10550 {
lab=ob9}
N 11070 -10670 11210 -10670 {
lab=p_b}
N 11100 -10670 11100 -10590 {
lab=p_b}
N 11250 -10450 11250 -10430 {
lab=VDD}
N 11030 -10450 11250 -10450 {
lab=VDD}
N 11030 -10450 11030 -10440 {
lab=VDD}
N 11070 -10410 11170 -10410 {
lab=o9}
N 11170 -10410 11170 -10350 {
lab=o9}
N 11170 -10350 11250 -10350 {
lab=o9}
N 11250 -10370 11250 -10350 {
lab=o9}
N 11290 -10400 11320 -10400 {
lab=ob9}
N 11320 -10400 11320 -10330 {
lab=ob9}
N 11030 -10330 11320 -10330 {
lab=ob9}
N 11030 -10380 11030 -10330 {
lab=ob9}
N 11250 -10350 11250 -10270 {
lab=o9}
N 11030 -10330 11030 -10280 {
lab=ob9}
N 11030 -10220 11030 -10190 {
lab=#net67}
N 11030 -10190 11250 -10190 {
lab=#net67}
N 11250 -10210 11250 -10190 {
lab=#net67}
N 11120 -10190 11120 -10130 {
lab=#net67}
N 11120 -10070 11120 -10040 {
lab=GND}
N 11000 -10100 11080 -10100 {
lab=VDD}
N 10970 -10250 10990 -10250 {
lab=o9}
N 10970 -10350 10970 -10250 {
lab=o9}
N 10970 -10350 11090 -10350 {
lab=o9}
N 11090 -10410 11090 -10350 {
lab=o9}
N 11180 -10240 11210 -10240 {
lab=ob9}
N 11180 -10330 11180 -10240 {
lab=ob9}
N 10930 -10330 11030 -10330 {
lab=ob9}
N 10930 -10550 10930 -10330 {
lab=ob9}
N 10930 -10550 10970 -10550 {
lab=ob9}
N 11250 -10550 11360 -10550 {
lab=o9}
N 11360 -10550 11360 -10320 {
lab=o9}
N 11250 -10320 11360 -10320 {
lab=o9}
N 10810 -10330 10930 -10330 {
lab=ob9}
N 11360 -10320 11450 -10320 {
lab=o9}
N 10780 -10420 10780 -10370 {
lab=rd}
N 11480 -10400 11480 -10360 {
lab=rd}
N 11510 -10320 11580 -10320 {
lab=b9}
N 10690 -10330 10750 -10330 {
lab=blb9}
N 11400 -10390 11400 -10320 {
lab=o9}
N 10870 -10420 10870 -10330 {
lab=ob9}
N 10700 -10860 10700 -10330 {
lab=blb9}
N 10700 -10860 10710 -10860 {
lab=blb9}
N 11560 -10800 11560 -10320 {
lab=b9}
N 10720 -10800 11560 -10800 {
lab=b9}
N 10720 -11000 10720 -10800 {
lab=b9}
N 10540 -11030 10540 -11020 {
lab=blb9}
N 10500 -11030 10500 -11000 {
lab=b9}
N 10300 -10690 10300 -10650 {
lab=#net68}
N 10300 -10420 10300 -10380 {
lab=#net69}
N 10100 -10720 10260 -10720 {
lab=#net70}
N 10100 -10720 10100 -10570 {
lab=#net70}
N 10100 -10570 10100 -10130 {
lab=#net70}
N 10100 -10130 10260 -10130 {
lab=#net70}
N 12530 -11000 12550 -11000 {
lab=blb10}
N 12530 -10980 12560 -10980 {
lab=b10}
N 13300 -11090 13300 -11000 {
lab=q10}
N 13460 -11090 13460 -11000 {
lab=qb10}
N 13340 -11120 13340 -10970 {
lab=qb10}
N 13420 -11120 13420 -10970 {
lab=q10}
N 13300 -11180 13300 -11150 {
lab=VDD}
N 13300 -11180 13460 -11180 {
lab=VDD}
N 13460 -11180 13460 -11150 {
lab=VDD}
N 13300 -10940 13300 -10900 {
lab=GND}
N 13300 -10900 13460 -10900 {
lab=GND}
N 13460 -10940 13460 -10900 {
lab=GND}
N 13380 -10900 13380 -10880 {
lab=GND}
N 13380 -11200 13380 -11180 {
lab=VDD}
N 13150 -11020 13300 -11020 {
lab=q10}
N 13460 -11030 13580 -11030 {
lab=qb10}
N 13340 -11030 13460 -11030 {
lab=qb10}
N 13040 -11020 13090 -11020 {
lab=b10}
N 13640 -11030 13680 -11030 {
lab=blb10}
N 13120 -11240 13120 -11060 {
lab=WL}
N 13120 -11240 13610 -11240 {
lab=WL}
N 13610 -11240 13610 -11070 {
lab=WL}
N 13040 -11240 13120 -11240 {
lab=WL}
N 13300 -11020 13420 -11020 {
lab=q10}
N 13540 -11070 13540 -11030 {
lab=qb10}
N 13210 -11060 13210 -11020 {
lab=q10}
N 12560 -10980 13040 -10980 {
lab=b10}
N 13040 -11020 13040 -10980 {
lab=b10}
N 12550 -11000 13030 -11000 {
lab=blb10}
N 13030 -11000 13030 -10840 {
lab=blb10}
N 13030 -10840 13690 -10840 {
lab=blb10}
N 13690 -11030 13690 -10840 {
lab=blb10}
N 13680 -11030 13690 -11030 {
lab=blb10}
N 12620 -10570 12620 -10460 {
lab=blb10}
N 12540 -10600 12580 -10600 {
lab=d10}
N 12540 -10600 12540 -10430 {
lab=d10}
N 12540 -10430 12580 -10430 {
lab=d10}
N 12620 -10080 12620 -10040 {
lab=#net71}
N 12620 -9980 12620 -9870 {
lab=b10}
N 12620 -9810 12620 -9770 {
lab=#net72}
N 12540 -10010 12580 -10010 {
lab=#net73}
N 12540 -10010 12540 -9840 {
lab=#net73}
N 12540 -9840 12580 -9840 {
lab=#net73}
N 12370 -9740 12580 -9740 {
lab=we}
N 12300 -9740 12370 -9740 {
lab=we}
N 12300 -10540 12300 -9740 {
lab=we}
N 12300 -10550 12300 -10540 {
lab=we}
N 12300 -10550 12360 -10550 {
lab=we}
N 12300 -10330 12580 -10330 {
lab=we}
N 12310 -10520 12310 -10440 {
lab=d10}
N 12310 -10520 12540 -10520 {
lab=d10}
N 12310 -10450 12310 -9920 {
lab=d10}
N 12310 -9920 12340 -9920 {
lab=d10}
N 12400 -9920 12540 -9920 {
lab=#net73}
N 12620 -9710 12620 -9670 {
lab=GND}
N 12620 -10300 12620 -10260 {
lab=GND}
N 12620 -10770 12620 -10730 {
lab=VDD}
N 12620 -10160 12620 -10140 {
lab=VDD}
N 12620 -10520 12780 -10520 {
lab=blb10}
N 12620 -9930 12770 -9930 {
lab=b10}
N 12770 -9930 12780 -9930 {
lab=b10}
N 12220 -10550 12300 -10550 {
lab=we}
N 12220 -9920 12310 -9920 {
lab=d10}
N 12750 -11000 12750 -10520 {
lab=blb10}
N 12760 -10980 12760 -9930 {
lab=b10}
N 12210 -11130 12210 -11040 {
lab=b10}
N 12120 -11130 12210 -11130 {
lab=b10}
N 12210 -10980 12210 -10910 {
lab=blb10}
N 12120 -10910 12210 -10910 {
lab=blb10}
N 12020 -10910 12060 -10910 {
lab=VDD}
N 12020 -11130 12020 -10910 {
lab=VDD}
N 12020 -11130 12060 -11130 {
lab=VDD}
N 12170 -11010 12170 -10840 {
lab=p_b}
N 12020 -10910 12020 -10830 {
lab=VDD}
N 12210 -11130 12280 -11130 {
lab=b10}
N 12090 -11090 12090 -10950 {
lab=p_b}
N 12090 -10980 12170 -10980 {
lab=p_b}
N 12430 -11000 12530 -11000 {
lab=blb10}
N 12430 -11000 12430 -10920 {
lab=blb10}
N 12210 -10920 12430 -10920 {
lab=blb10}
N 12280 -10980 12530 -10980 {
lab=b10}
N 12280 -11130 12280 -10980 {
lab=b10}
N 13480 -10530 13570 -10530 {
lab=o10}
N 13570 -10620 13570 -10530 {
lab=o10}
N 13350 -10530 13420 -10530 {
lab=ob10}
N 13350 -10620 13350 -10530 {
lab=ob10}
N 13350 -10720 13350 -10680 {
lab=VDD}
N 13350 -10720 13570 -10720 {
lab=VDD}
N 13570 -10720 13570 -10680 {
lab=VDD}
N 13280 -10570 13450 -10570 {
lab=p_b}
N 13270 -10720 13350 -10720 {
lab=VDD}
N 13280 -10530 13350 -10530 {
lab=ob10}
N 13390 -10650 13530 -10650 {
lab=p_b}
N 13420 -10650 13420 -10570 {
lab=p_b}
N 13570 -10430 13570 -10410 {
lab=VDD}
N 13350 -10430 13570 -10430 {
lab=VDD}
N 13350 -10430 13350 -10420 {
lab=VDD}
N 13390 -10390 13490 -10390 {
lab=o10}
N 13490 -10390 13490 -10330 {
lab=o10}
N 13490 -10330 13570 -10330 {
lab=o10}
N 13570 -10350 13570 -10330 {
lab=o10}
N 13610 -10380 13640 -10380 {
lab=ob10}
N 13640 -10380 13640 -10310 {
lab=ob10}
N 13350 -10310 13640 -10310 {
lab=ob10}
N 13350 -10360 13350 -10310 {
lab=ob10}
N 13570 -10330 13570 -10250 {
lab=o10}
N 13350 -10310 13350 -10260 {
lab=ob10}
N 13350 -10200 13350 -10170 {
lab=#net74}
N 13350 -10170 13570 -10170 {
lab=#net74}
N 13570 -10190 13570 -10170 {
lab=#net74}
N 13440 -10170 13440 -10110 {
lab=#net74}
N 13440 -10050 13440 -10020 {
lab=GND}
N 13320 -10080 13400 -10080 {
lab=VDD}
N 13290 -10230 13310 -10230 {
lab=o10}
N 13290 -10330 13290 -10230 {
lab=o10}
N 13290 -10330 13410 -10330 {
lab=o10}
N 13410 -10390 13410 -10330 {
lab=o10}
N 13500 -10220 13530 -10220 {
lab=ob10}
N 13500 -10310 13500 -10220 {
lab=ob10}
N 13250 -10310 13350 -10310 {
lab=ob10}
N 13250 -10530 13250 -10310 {
lab=ob10}
N 13250 -10530 13290 -10530 {
lab=ob10}
N 13570 -10530 13680 -10530 {
lab=o10}
N 13680 -10530 13680 -10300 {
lab=o10}
N 13570 -10300 13680 -10300 {
lab=o10}
N 13130 -10310 13250 -10310 {
lab=ob10}
N 13680 -10300 13770 -10300 {
lab=o10}
N 13100 -10400 13100 -10350 {
lab=rd}
N 13800 -10380 13800 -10340 {
lab=rd}
N 13830 -10300 13900 -10300 {
lab=b10}
N 13010 -10310 13070 -10310 {
lab=blb10}
N 13720 -10370 13720 -10300 {
lab=o10}
N 13190 -10400 13190 -10310 {
lab=ob10}
N 13020 -10840 13020 -10310 {
lab=blb10}
N 13020 -10840 13030 -10840 {
lab=blb10}
N 13880 -10780 13880 -10300 {
lab=b10}
N 13040 -10780 13880 -10780 {
lab=b10}
N 13040 -10980 13040 -10780 {
lab=b10}
N 12860 -11010 12860 -11000 {
lab=blb10}
N 12820 -11010 12820 -10980 {
lab=b10}
N 12620 -10670 12620 -10630 {
lab=#net75}
N 12620 -10400 12620 -10360 {
lab=#net76}
N 12420 -10700 12580 -10700 {
lab=#net77}
N 12420 -10700 12420 -10550 {
lab=#net77}
N 12420 -10550 12420 -10110 {
lab=#net77}
N 12420 -10110 12580 -10110 {
lab=#net77}
N 14680 -10990 14700 -10990 {
lab=blb11}
N 14680 -10970 14710 -10970 {
lab=b11}
N 15450 -11080 15450 -10990 {
lab=q11}
N 15610 -11080 15610 -10990 {
lab=qb11}
N 15490 -11110 15490 -10960 {
lab=qb11}
N 15570 -11110 15570 -10960 {
lab=q11}
N 15450 -11170 15450 -11140 {
lab=VDD}
N 15450 -11170 15610 -11170 {
lab=VDD}
N 15610 -11170 15610 -11140 {
lab=VDD}
N 15450 -10930 15450 -10890 {
lab=GND}
N 15450 -10890 15610 -10890 {
lab=GND}
N 15610 -10930 15610 -10890 {
lab=GND}
N 15530 -10890 15530 -10870 {
lab=GND}
N 15530 -11190 15530 -11170 {
lab=VDD}
N 15300 -11010 15450 -11010 {
lab=q11}
N 15610 -11020 15730 -11020 {
lab=qb11}
N 15490 -11020 15610 -11020 {
lab=qb11}
N 15190 -11010 15240 -11010 {
lab=b11}
N 15790 -11020 15830 -11020 {
lab=blb11}
N 15270 -11230 15270 -11050 {
lab=WL}
N 15270 -11230 15760 -11230 {
lab=WL}
N 15760 -11230 15760 -11060 {
lab=WL}
N 15190 -11230 15270 -11230 {
lab=WL}
N 15450 -11010 15570 -11010 {
lab=q11}
N 15690 -11060 15690 -11020 {
lab=qb11}
N 15360 -11050 15360 -11010 {
lab=q11}
N 14710 -10970 15190 -10970 {
lab=b11}
N 15190 -11010 15190 -10970 {
lab=b11}
N 14700 -10990 15180 -10990 {
lab=blb11}
N 15180 -10990 15180 -10830 {
lab=blb11}
N 15180 -10830 15840 -10830 {
lab=blb11}
N 15840 -11020 15840 -10830 {
lab=blb11}
N 15830 -11020 15840 -11020 {
lab=blb11}
N 14770 -10560 14770 -10450 {
lab=blb11}
N 14690 -10590 14730 -10590 {
lab=d11}
N 14690 -10590 14690 -10420 {
lab=d11}
N 14690 -10420 14730 -10420 {
lab=d11}
N 14770 -10070 14770 -10030 {
lab=#net78}
N 14770 -9970 14770 -9860 {
lab=b11}
N 14770 -9800 14770 -9760 {
lab=#net79}
N 14690 -10000 14730 -10000 {
lab=#net80}
N 14690 -10000 14690 -9830 {
lab=#net80}
N 14690 -9830 14730 -9830 {
lab=#net80}
N 14520 -9730 14730 -9730 {
lab=we}
N 14450 -9730 14520 -9730 {
lab=we}
N 14450 -10530 14450 -9730 {
lab=we}
N 14450 -10540 14450 -10530 {
lab=we}
N 14450 -10540 14510 -10540 {
lab=we}
N 14450 -10320 14730 -10320 {
lab=we}
N 14460 -10510 14460 -10430 {
lab=d11}
N 14460 -10510 14690 -10510 {
lab=d11}
N 14460 -10440 14460 -9910 {
lab=d11}
N 14460 -9910 14490 -9910 {
lab=d11}
N 14550 -9910 14690 -9910 {
lab=#net80}
N 14770 -9700 14770 -9660 {
lab=GND}
N 14770 -10290 14770 -10250 {
lab=GND}
N 14770 -10760 14770 -10720 {
lab=VDD}
N 14770 -10150 14770 -10130 {
lab=VDD}
N 14770 -10510 14930 -10510 {
lab=blb11}
N 14770 -9920 14920 -9920 {
lab=b11}
N 14920 -9920 14930 -9920 {
lab=b11}
N 14370 -10540 14450 -10540 {
lab=we}
N 14370 -9910 14460 -9910 {
lab=d11}
N 14900 -10990 14900 -10510 {
lab=blb11}
N 14910 -10970 14910 -9920 {
lab=b11}
N 14360 -11120 14360 -11030 {
lab=b11}
N 14270 -11120 14360 -11120 {
lab=b11}
N 14360 -10970 14360 -10900 {
lab=blb11}
N 14270 -10900 14360 -10900 {
lab=blb11}
N 14170 -10900 14210 -10900 {
lab=VDD}
N 14170 -11120 14170 -10900 {
lab=VDD}
N 14170 -11120 14210 -11120 {
lab=VDD}
N 14320 -11000 14320 -10830 {
lab=p_b}
N 14170 -10900 14170 -10820 {
lab=VDD}
N 14360 -11120 14430 -11120 {
lab=b11}
N 14240 -11080 14240 -10940 {
lab=p_b}
N 14240 -10970 14320 -10970 {
lab=p_b}
N 14580 -10990 14680 -10990 {
lab=blb11}
N 14580 -10990 14580 -10910 {
lab=blb11}
N 14360 -10910 14580 -10910 {
lab=blb11}
N 14430 -10970 14680 -10970 {
lab=b11}
N 14430 -11120 14430 -10970 {
lab=b11}
N 15630 -10520 15720 -10520 {
lab=o11}
N 15720 -10610 15720 -10520 {
lab=o11}
N 15500 -10520 15570 -10520 {
lab=ob11}
N 15500 -10610 15500 -10520 {
lab=ob11}
N 15500 -10710 15500 -10670 {
lab=VDD}
N 15500 -10710 15720 -10710 {
lab=VDD}
N 15720 -10710 15720 -10670 {
lab=VDD}
N 15430 -10560 15600 -10560 {
lab=p_b}
N 15420 -10710 15500 -10710 {
lab=VDD}
N 15430 -10520 15500 -10520 {
lab=ob11}
N 15540 -10640 15680 -10640 {
lab=p_b}
N 15570 -10640 15570 -10560 {
lab=p_b}
N 15720 -10420 15720 -10400 {
lab=VDD}
N 15500 -10420 15720 -10420 {
lab=VDD}
N 15500 -10420 15500 -10410 {
lab=VDD}
N 15540 -10380 15640 -10380 {
lab=o11}
N 15640 -10380 15640 -10320 {
lab=o11}
N 15640 -10320 15720 -10320 {
lab=o11}
N 15720 -10340 15720 -10320 {
lab=o11}
N 15760 -10370 15790 -10370 {
lab=ob11}
N 15790 -10370 15790 -10300 {
lab=ob11}
N 15500 -10300 15790 -10300 {
lab=ob11}
N 15500 -10350 15500 -10300 {
lab=ob11}
N 15720 -10320 15720 -10240 {
lab=o11}
N 15500 -10300 15500 -10250 {
lab=ob11}
N 15500 -10190 15500 -10160 {
lab=#net81}
N 15500 -10160 15720 -10160 {
lab=#net81}
N 15720 -10180 15720 -10160 {
lab=#net81}
N 15590 -10160 15590 -10100 {
lab=#net81}
N 15590 -10040 15590 -10010 {
lab=GND}
N 15470 -10070 15550 -10070 {
lab=VDD}
N 15440 -10220 15460 -10220 {
lab=o11}
N 15440 -10320 15440 -10220 {
lab=o11}
N 15440 -10320 15560 -10320 {
lab=o11}
N 15560 -10380 15560 -10320 {
lab=o11}
N 15650 -10210 15680 -10210 {
lab=ob11}
N 15650 -10300 15650 -10210 {
lab=ob11}
N 15400 -10300 15500 -10300 {
lab=ob11}
N 15400 -10520 15400 -10300 {
lab=ob11}
N 15400 -10520 15440 -10520 {
lab=ob11}
N 15720 -10520 15830 -10520 {
lab=o11}
N 15830 -10520 15830 -10290 {
lab=o11}
N 15720 -10290 15830 -10290 {
lab=o11}
N 15280 -10300 15400 -10300 {
lab=ob11}
N 15830 -10290 15920 -10290 {
lab=o11}
N 15250 -10390 15250 -10340 {
lab=rd}
N 15950 -10370 15950 -10330 {
lab=rd}
N 15980 -10290 16050 -10290 {
lab=b11}
N 15160 -10300 15220 -10300 {
lab=blb11}
N 15870 -10360 15870 -10290 {
lab=o11}
N 15340 -10390 15340 -10300 {
lab=ob11}
N 15170 -10830 15170 -10300 {
lab=blb11}
N 15170 -10830 15180 -10830 {
lab=blb11}
N 16030 -10770 16030 -10290 {
lab=b11}
N 15190 -10770 16030 -10770 {
lab=b11}
N 15190 -10970 15190 -10770 {
lab=b11}
N 15010 -11000 15010 -10990 {
lab=blb11}
N 14970 -11000 14970 -10970 {
lab=b11}
N 14770 -10660 14770 -10620 {
lab=#net82}
N 14770 -10390 14770 -10350 {
lab=#net83}
N 14570 -10690 14730 -10690 {
lab=#net84}
N 14570 -10690 14570 -10540 {
lab=#net84}
N 14570 -10540 14570 -10100 {
lab=#net84}
N 14570 -10100 14730 -10100 {
lab=#net84}
N 3690 -8790 3710 -8790 {
lab=blb12}
N 3690 -8770 3720 -8770 {
lab=b12}
N 4460 -8880 4460 -8790 {
lab=q12}
N 4620 -8880 4620 -8790 {
lab=qb12}
N 4500 -8910 4500 -8760 {
lab=qb12}
N 4580 -8910 4580 -8760 {
lab=q12}
N 4460 -8970 4460 -8940 {
lab=VDD}
N 4460 -8970 4620 -8970 {
lab=VDD}
N 4620 -8970 4620 -8940 {
lab=VDD}
N 4460 -8730 4460 -8690 {
lab=GND}
N 4460 -8690 4620 -8690 {
lab=GND}
N 4620 -8730 4620 -8690 {
lab=GND}
N 4540 -8690 4540 -8670 {
lab=GND}
N 4540 -8990 4540 -8970 {
lab=VDD}
N 4310 -8810 4460 -8810 {
lab=q12}
N 4620 -8820 4740 -8820 {
lab=qb12}
N 4500 -8820 4620 -8820 {
lab=qb12}
N 4200 -8810 4250 -8810 {
lab=b12}
N 4800 -8820 4840 -8820 {
lab=blb12}
N 4280 -9030 4280 -8850 {
lab=WL}
N 4280 -9030 4770 -9030 {
lab=WL}
N 4770 -9030 4770 -8860 {
lab=WL}
N 4200 -9030 4280 -9030 {
lab=WL}
N 4460 -8810 4580 -8810 {
lab=q12}
N 4700 -8860 4700 -8820 {
lab=qb12}
N 4370 -8850 4370 -8810 {
lab=q12}
N 3720 -8770 4200 -8770 {
lab=b12}
N 4200 -8810 4200 -8770 {
lab=b12}
N 3710 -8790 4190 -8790 {
lab=blb12}
N 4190 -8790 4190 -8630 {
lab=blb12}
N 4190 -8630 4850 -8630 {
lab=blb12}
N 4850 -8820 4850 -8630 {
lab=blb12}
N 4840 -8820 4850 -8820 {
lab=blb12}
N 3780 -8360 3780 -8250 {
lab=blb12}
N 3700 -8390 3740 -8390 {
lab=d12}
N 3700 -8390 3700 -8220 {
lab=d12}
N 3700 -8220 3740 -8220 {
lab=d12}
N 3780 -7870 3780 -7830 {
lab=#net85}
N 3780 -7770 3780 -7660 {
lab=b12}
N 3780 -7600 3780 -7560 {
lab=#net86}
N 3700 -7800 3740 -7800 {
lab=#net87}
N 3700 -7800 3700 -7630 {
lab=#net87}
N 3700 -7630 3740 -7630 {
lab=#net87}
N 3530 -7530 3740 -7530 {
lab=we}
N 3460 -7530 3530 -7530 {
lab=we}
N 3460 -8330 3460 -7530 {
lab=we}
N 3460 -8340 3460 -8330 {
lab=we}
N 3460 -8340 3520 -8340 {
lab=we}
N 3460 -8120 3740 -8120 {
lab=we}
N 3470 -8310 3470 -8230 {
lab=d12}
N 3470 -8310 3700 -8310 {
lab=d12}
N 3470 -8240 3470 -7710 {
lab=d12}
N 3470 -7710 3500 -7710 {
lab=d12}
N 3560 -7710 3700 -7710 {
lab=#net87}
N 3780 -7500 3780 -7460 {
lab=GND}
N 3780 -8090 3780 -8050 {
lab=GND}
N 3780 -8560 3780 -8520 {
lab=VDD}
N 3780 -7950 3780 -7930 {
lab=VDD}
N 3780 -8310 3940 -8310 {
lab=blb12}
N 3780 -7720 3930 -7720 {
lab=b12}
N 3930 -7720 3940 -7720 {
lab=b12}
N 3380 -8340 3460 -8340 {
lab=we}
N 3380 -7710 3470 -7710 {
lab=d12}
N 3910 -8790 3910 -8310 {
lab=blb12}
N 3920 -8770 3920 -7720 {
lab=b12}
N 3370 -8920 3370 -8830 {
lab=b12}
N 3280 -8920 3370 -8920 {
lab=b12}
N 3370 -8770 3370 -8700 {
lab=blb12}
N 3280 -8700 3370 -8700 {
lab=blb12}
N 3180 -8700 3220 -8700 {
lab=VDD}
N 3180 -8920 3180 -8700 {
lab=VDD}
N 3180 -8920 3220 -8920 {
lab=VDD}
N 3330 -8800 3330 -8630 {
lab=p_b}
N 3180 -8700 3180 -8620 {
lab=VDD}
N 3370 -8920 3440 -8920 {
lab=b12}
N 3250 -8880 3250 -8740 {
lab=p_b}
N 3250 -8770 3330 -8770 {
lab=p_b}
N 3590 -8790 3690 -8790 {
lab=blb12}
N 3590 -8790 3590 -8710 {
lab=blb12}
N 3370 -8710 3590 -8710 {
lab=blb12}
N 3440 -8770 3690 -8770 {
lab=b12}
N 3440 -8920 3440 -8770 {
lab=b12}
N 4640 -8320 4730 -8320 {
lab=o12}
N 4730 -8410 4730 -8320 {
lab=o12}
N 4510 -8320 4580 -8320 {
lab=ob12}
N 4510 -8410 4510 -8320 {
lab=ob12}
N 4510 -8510 4510 -8470 {
lab=VDD}
N 4510 -8510 4730 -8510 {
lab=VDD}
N 4730 -8510 4730 -8470 {
lab=VDD}
N 4440 -8360 4610 -8360 {
lab=p_b}
N 4430 -8510 4510 -8510 {
lab=VDD}
N 4440 -8320 4510 -8320 {
lab=ob12}
N 4550 -8440 4690 -8440 {
lab=p_b}
N 4580 -8440 4580 -8360 {
lab=p_b}
N 4730 -8220 4730 -8200 {
lab=VDD}
N 4510 -8220 4730 -8220 {
lab=VDD}
N 4510 -8220 4510 -8210 {
lab=VDD}
N 4550 -8180 4650 -8180 {
lab=o12}
N 4650 -8180 4650 -8120 {
lab=o12}
N 4650 -8120 4730 -8120 {
lab=o12}
N 4730 -8140 4730 -8120 {
lab=o12}
N 4770 -8170 4800 -8170 {
lab=ob12}
N 4800 -8170 4800 -8100 {
lab=ob12}
N 4510 -8100 4800 -8100 {
lab=ob12}
N 4510 -8150 4510 -8100 {
lab=ob12}
N 4730 -8120 4730 -8040 {
lab=o12}
N 4510 -8100 4510 -8050 {
lab=ob12}
N 4510 -7990 4510 -7960 {
lab=#net88}
N 4510 -7960 4730 -7960 {
lab=#net88}
N 4730 -7980 4730 -7960 {
lab=#net88}
N 4600 -7960 4600 -7900 {
lab=#net88}
N 4600 -7840 4600 -7810 {
lab=GND}
N 4480 -7870 4560 -7870 {
lab=VDD}
N 4450 -8020 4470 -8020 {
lab=o12}
N 4450 -8120 4450 -8020 {
lab=o12}
N 4450 -8120 4570 -8120 {
lab=o12}
N 4570 -8180 4570 -8120 {
lab=o12}
N 4660 -8010 4690 -8010 {
lab=ob12}
N 4660 -8100 4660 -8010 {
lab=ob12}
N 4410 -8100 4510 -8100 {
lab=ob12}
N 4410 -8320 4410 -8100 {
lab=ob12}
N 4410 -8320 4450 -8320 {
lab=ob12}
N 4730 -8320 4840 -8320 {
lab=o12}
N 4840 -8320 4840 -8090 {
lab=o12}
N 4730 -8090 4840 -8090 {
lab=o12}
N 4290 -8100 4410 -8100 {
lab=ob12}
N 4840 -8090 4930 -8090 {
lab=o12}
N 4260 -8190 4260 -8140 {
lab=rd}
N 4960 -8170 4960 -8130 {
lab=rd}
N 4990 -8090 5060 -8090 {
lab=b12}
N 4170 -8100 4230 -8100 {
lab=blb12}
N 4880 -8160 4880 -8090 {
lab=o12}
N 4350 -8190 4350 -8100 {
lab=ob12}
N 4180 -8630 4180 -8100 {
lab=blb12}
N 4180 -8630 4190 -8630 {
lab=blb12}
N 5040 -8570 5040 -8090 {
lab=b12}
N 4200 -8570 5040 -8570 {
lab=b12}
N 4200 -8770 4200 -8570 {
lab=b12}
N 4020 -8800 4020 -8790 {
lab=blb12}
N 3980 -8800 3980 -8770 {
lab=b12}
N 3780 -8460 3780 -8420 {
lab=#net89}
N 3780 -8190 3780 -8150 {
lab=#net90}
N 3580 -8490 3740 -8490 {
lab=#net91}
N 3580 -8490 3580 -8340 {
lab=#net91}
N 3580 -8340 3580 -7900 {
lab=#net91}
N 3580 -7900 3740 -7900 {
lab=#net91}
N 6010 -8770 6030 -8770 {
lab=blb13}
N 6010 -8750 6040 -8750 {
lab=b13}
N 6780 -8860 6780 -8770 {
lab=q13}
N 6940 -8860 6940 -8770 {
lab=qb13}
N 6820 -8890 6820 -8740 {
lab=qb13}
N 6900 -8890 6900 -8740 {
lab=q13}
N 6780 -8950 6780 -8920 {
lab=VDD}
N 6780 -8950 6940 -8950 {
lab=VDD}
N 6940 -8950 6940 -8920 {
lab=VDD}
N 6780 -8710 6780 -8670 {
lab=GND}
N 6780 -8670 6940 -8670 {
lab=GND}
N 6940 -8710 6940 -8670 {
lab=GND}
N 6860 -8670 6860 -8650 {
lab=GND}
N 6860 -8970 6860 -8950 {
lab=VDD}
N 6630 -8790 6780 -8790 {
lab=q13}
N 6940 -8800 7060 -8800 {
lab=qb13}
N 6820 -8800 6940 -8800 {
lab=qb13}
N 6520 -8790 6570 -8790 {
lab=b13}
N 7120 -8800 7160 -8800 {
lab=blb13}
N 6600 -9010 6600 -8830 {
lab=WL}
N 6600 -9010 7090 -9010 {
lab=WL}
N 7090 -9010 7090 -8840 {
lab=WL}
N 6520 -9010 6600 -9010 {
lab=WL}
N 6780 -8790 6900 -8790 {
lab=q13}
N 7020 -8840 7020 -8800 {
lab=qb13}
N 6690 -8830 6690 -8790 {
lab=q13}
N 6040 -8750 6520 -8750 {
lab=b13}
N 6520 -8790 6520 -8750 {
lab=b13}
N 6030 -8770 6510 -8770 {
lab=blb13}
N 6510 -8770 6510 -8610 {
lab=blb13}
N 6510 -8610 7170 -8610 {
lab=blb13}
N 7170 -8800 7170 -8610 {
lab=blb13}
N 7160 -8800 7170 -8800 {
lab=blb13}
N 6100 -8340 6100 -8230 {
lab=blb13}
N 6020 -8370 6060 -8370 {
lab=d13}
N 6020 -8370 6020 -8200 {
lab=d13}
N 6020 -8200 6060 -8200 {
lab=d13}
N 6100 -7850 6100 -7810 {
lab=#net92}
N 6100 -7750 6100 -7640 {
lab=b13}
N 6100 -7580 6100 -7540 {
lab=#net93}
N 6020 -7780 6060 -7780 {
lab=#net94}
N 6020 -7780 6020 -7610 {
lab=#net94}
N 6020 -7610 6060 -7610 {
lab=#net94}
N 5850 -7510 6060 -7510 {
lab=we}
N 5780 -7510 5850 -7510 {
lab=we}
N 5780 -8310 5780 -7510 {
lab=we}
N 5780 -8320 5780 -8310 {
lab=we}
N 5780 -8320 5840 -8320 {
lab=we}
N 5780 -8100 6060 -8100 {
lab=we}
N 5790 -8290 5790 -8210 {
lab=d13}
N 5790 -8290 6020 -8290 {
lab=d13}
N 5790 -8220 5790 -7690 {
lab=d13}
N 5790 -7690 5820 -7690 {
lab=d13}
N 5880 -7690 6020 -7690 {
lab=#net94}
N 6100 -7480 6100 -7440 {
lab=GND}
N 6100 -8070 6100 -8030 {
lab=GND}
N 6100 -8540 6100 -8500 {
lab=VDD}
N 6100 -7930 6100 -7910 {
lab=VDD}
N 6100 -8290 6260 -8290 {
lab=blb13}
N 6100 -7700 6250 -7700 {
lab=b13}
N 6250 -7700 6260 -7700 {
lab=b13}
N 5700 -8320 5780 -8320 {
lab=we}
N 5700 -7690 5790 -7690 {
lab=d13}
N 6230 -8770 6230 -8290 {
lab=blb13}
N 6240 -8750 6240 -7700 {
lab=b13}
N 5690 -8900 5690 -8810 {
lab=b13}
N 5600 -8900 5690 -8900 {
lab=b13}
N 5690 -8750 5690 -8680 {
lab=blb13}
N 5600 -8680 5690 -8680 {
lab=blb13}
N 5500 -8680 5540 -8680 {
lab=VDD}
N 5500 -8900 5500 -8680 {
lab=VDD}
N 5500 -8900 5540 -8900 {
lab=VDD}
N 5650 -8780 5650 -8610 {
lab=p_b}
N 5500 -8680 5500 -8600 {
lab=VDD}
N 5690 -8900 5760 -8900 {
lab=b13}
N 5570 -8860 5570 -8720 {
lab=p_b}
N 5570 -8750 5650 -8750 {
lab=p_b}
N 5910 -8770 6010 -8770 {
lab=blb13}
N 5910 -8770 5910 -8690 {
lab=blb13}
N 5690 -8690 5910 -8690 {
lab=blb13}
N 5760 -8750 6010 -8750 {
lab=b13}
N 5760 -8900 5760 -8750 {
lab=b13}
N 6960 -8300 7050 -8300 {
lab=o13}
N 7050 -8390 7050 -8300 {
lab=o13}
N 6830 -8300 6900 -8300 {
lab=ob13}
N 6830 -8390 6830 -8300 {
lab=ob13}
N 6830 -8490 6830 -8450 {
lab=VDD}
N 6830 -8490 7050 -8490 {
lab=VDD}
N 7050 -8490 7050 -8450 {
lab=VDD}
N 6760 -8340 6930 -8340 {
lab=p_b}
N 6750 -8490 6830 -8490 {
lab=VDD}
N 6760 -8300 6830 -8300 {
lab=ob13}
N 6870 -8420 7010 -8420 {
lab=p_b}
N 6900 -8420 6900 -8340 {
lab=p_b}
N 7050 -8200 7050 -8180 {
lab=VDD}
N 6830 -8200 7050 -8200 {
lab=VDD}
N 6830 -8200 6830 -8190 {
lab=VDD}
N 6870 -8160 6970 -8160 {
lab=o13}
N 6970 -8160 6970 -8100 {
lab=o13}
N 6970 -8100 7050 -8100 {
lab=o13}
N 7050 -8120 7050 -8100 {
lab=o13}
N 7090 -8150 7120 -8150 {
lab=ob13}
N 7120 -8150 7120 -8080 {
lab=ob13}
N 6830 -8080 7120 -8080 {
lab=ob13}
N 6830 -8130 6830 -8080 {
lab=ob13}
N 7050 -8100 7050 -8020 {
lab=o13}
N 6830 -8080 6830 -8030 {
lab=ob13}
N 6830 -7970 6830 -7940 {
lab=#net95}
N 6830 -7940 7050 -7940 {
lab=#net95}
N 7050 -7960 7050 -7940 {
lab=#net95}
N 6920 -7940 6920 -7880 {
lab=#net95}
N 6920 -7820 6920 -7790 {
lab=GND}
N 6800 -7850 6880 -7850 {
lab=VDD}
N 6770 -8000 6790 -8000 {
lab=o13}
N 6770 -8100 6770 -8000 {
lab=o13}
N 6770 -8100 6890 -8100 {
lab=o13}
N 6890 -8160 6890 -8100 {
lab=o13}
N 6980 -7990 7010 -7990 {
lab=ob13}
N 6980 -8080 6980 -7990 {
lab=ob13}
N 6730 -8080 6830 -8080 {
lab=ob13}
N 6730 -8300 6730 -8080 {
lab=ob13}
N 6730 -8300 6770 -8300 {
lab=ob13}
N 7050 -8300 7160 -8300 {
lab=o13}
N 7160 -8300 7160 -8070 {
lab=o13}
N 7050 -8070 7160 -8070 {
lab=o13}
N 6610 -8080 6730 -8080 {
lab=ob13}
N 7160 -8070 7250 -8070 {
lab=o13}
N 6580 -8170 6580 -8120 {
lab=rd}
N 7280 -8150 7280 -8110 {
lab=rd}
N 7310 -8070 7380 -8070 {
lab=b13}
N 6490 -8080 6550 -8080 {
lab=blb13}
N 7200 -8140 7200 -8070 {
lab=o13}
N 6670 -8170 6670 -8080 {
lab=ob13}
N 6500 -8610 6500 -8080 {
lab=blb13}
N 6500 -8610 6510 -8610 {
lab=blb13}
N 7360 -8550 7360 -8070 {
lab=b13}
N 6520 -8550 7360 -8550 {
lab=b13}
N 6520 -8750 6520 -8550 {
lab=b13}
N 6340 -8780 6340 -8770 {
lab=blb13}
N 6300 -8780 6300 -8750 {
lab=b13}
N 6100 -8440 6100 -8400 {
lab=#net96}
N 6100 -8170 6100 -8130 {
lab=#net97}
N 5900 -8470 6060 -8470 {
lab=#net98}
N 5900 -8470 5900 -8320 {
lab=#net98}
N 5900 -8320 5900 -7880 {
lab=#net98}
N 5900 -7880 6060 -7880 {
lab=#net98}
N 8160 -8760 8180 -8760 {
lab=blb14}
N 8160 -8740 8190 -8740 {
lab=b14}
N 8930 -8850 8930 -8760 {
lab=q14}
N 9090 -8850 9090 -8760 {
lab=qb14}
N 8970 -8880 8970 -8730 {
lab=qb14}
N 9050 -8880 9050 -8730 {
lab=q14}
N 8930 -8940 8930 -8910 {
lab=VDD}
N 8930 -8940 9090 -8940 {
lab=VDD}
N 9090 -8940 9090 -8910 {
lab=VDD}
N 8930 -8700 8930 -8660 {
lab=GND}
N 8930 -8660 9090 -8660 {
lab=GND}
N 9090 -8700 9090 -8660 {
lab=GND}
N 9010 -8660 9010 -8640 {
lab=GND}
N 9010 -8960 9010 -8940 {
lab=VDD}
N 8780 -8780 8930 -8780 {
lab=q14}
N 9090 -8790 9210 -8790 {
lab=qb14}
N 8970 -8790 9090 -8790 {
lab=qb14}
N 8670 -8780 8720 -8780 {
lab=b14}
N 9270 -8790 9310 -8790 {
lab=blb14}
N 8750 -9000 8750 -8820 {
lab=WL}
N 8750 -9000 9240 -9000 {
lab=WL}
N 9240 -9000 9240 -8830 {
lab=WL}
N 8670 -9000 8750 -9000 {
lab=WL}
N 8930 -8780 9050 -8780 {
lab=q14}
N 9170 -8830 9170 -8790 {
lab=qb14}
N 8840 -8820 8840 -8780 {
lab=q14}
N 8190 -8740 8670 -8740 {
lab=b14}
N 8670 -8780 8670 -8740 {
lab=b14}
N 8180 -8760 8660 -8760 {
lab=blb14}
N 8660 -8760 8660 -8600 {
lab=blb14}
N 8660 -8600 9320 -8600 {
lab=blb14}
N 9320 -8790 9320 -8600 {
lab=blb14}
N 9310 -8790 9320 -8790 {
lab=blb14}
N 8250 -8330 8250 -8220 {
lab=blb14}
N 8170 -8360 8210 -8360 {
lab=d14}
N 8170 -8360 8170 -8190 {
lab=d14}
N 8170 -8190 8210 -8190 {
lab=d14}
N 8250 -7840 8250 -7800 {
lab=#net99}
N 8250 -7740 8250 -7630 {
lab=b14}
N 8250 -7570 8250 -7530 {
lab=#net100}
N 8170 -7770 8210 -7770 {
lab=#net101}
N 8170 -7770 8170 -7600 {
lab=#net101}
N 8170 -7600 8210 -7600 {
lab=#net101}
N 8000 -7500 8210 -7500 {
lab=we}
N 7930 -7500 8000 -7500 {
lab=we}
N 7930 -8300 7930 -7500 {
lab=we}
N 7930 -8310 7930 -8300 {
lab=we}
N 7930 -8310 7990 -8310 {
lab=we}
N 7930 -8090 8210 -8090 {
lab=we}
N 7940 -8280 7940 -8200 {
lab=d14}
N 7940 -8280 8170 -8280 {
lab=d14}
N 7940 -8210 7940 -7680 {
lab=d14}
N 7940 -7680 7970 -7680 {
lab=d14}
N 8030 -7680 8170 -7680 {
lab=#net101}
N 8250 -7470 8250 -7430 {
lab=GND}
N 8250 -8060 8250 -8020 {
lab=GND}
N 8250 -8530 8250 -8490 {
lab=VDD}
N 8250 -7920 8250 -7900 {
lab=VDD}
N 8250 -8280 8410 -8280 {
lab=blb14}
N 8250 -7690 8400 -7690 {
lab=b14}
N 8400 -7690 8410 -7690 {
lab=b14}
N 7850 -8310 7930 -8310 {
lab=we}
N 7850 -7680 7940 -7680 {
lab=d14}
N 8380 -8760 8380 -8280 {
lab=blb14}
N 8390 -8740 8390 -7690 {
lab=b14}
N 7840 -8890 7840 -8800 {
lab=b14}
N 7750 -8890 7840 -8890 {
lab=b14}
N 7840 -8740 7840 -8670 {
lab=blb14}
N 7750 -8670 7840 -8670 {
lab=blb14}
N 7650 -8670 7690 -8670 {
lab=VDD}
N 7650 -8890 7650 -8670 {
lab=VDD}
N 7650 -8890 7690 -8890 {
lab=VDD}
N 7800 -8770 7800 -8600 {
lab=p_b}
N 7650 -8670 7650 -8590 {
lab=VDD}
N 7840 -8890 7910 -8890 {
lab=b14}
N 7720 -8850 7720 -8710 {
lab=p_b}
N 7720 -8740 7800 -8740 {
lab=p_b}
N 8060 -8760 8160 -8760 {
lab=blb14}
N 8060 -8760 8060 -8680 {
lab=blb14}
N 7840 -8680 8060 -8680 {
lab=blb14}
N 7910 -8740 8160 -8740 {
lab=b14}
N 7910 -8890 7910 -8740 {
lab=b14}
N 9110 -8290 9200 -8290 {
lab=o14}
N 9200 -8380 9200 -8290 {
lab=o14}
N 8980 -8290 9050 -8290 {
lab=ob14}
N 8980 -8380 8980 -8290 {
lab=ob14}
N 8980 -8480 8980 -8440 {
lab=VDD}
N 8980 -8480 9200 -8480 {
lab=VDD}
N 9200 -8480 9200 -8440 {
lab=VDD}
N 8910 -8330 9080 -8330 {
lab=p_b}
N 8900 -8480 8980 -8480 {
lab=VDD}
N 8910 -8290 8980 -8290 {
lab=ob14}
N 9020 -8410 9160 -8410 {
lab=p_b}
N 9050 -8410 9050 -8330 {
lab=p_b}
N 9200 -8190 9200 -8170 {
lab=VDD}
N 8980 -8190 9200 -8190 {
lab=VDD}
N 8980 -8190 8980 -8180 {
lab=VDD}
N 9020 -8150 9120 -8150 {
lab=o14}
N 9120 -8150 9120 -8090 {
lab=o14}
N 9120 -8090 9200 -8090 {
lab=o14}
N 9200 -8110 9200 -8090 {
lab=o14}
N 9240 -8140 9270 -8140 {
lab=ob14}
N 9270 -8140 9270 -8070 {
lab=ob14}
N 8980 -8070 9270 -8070 {
lab=ob14}
N 8980 -8120 8980 -8070 {
lab=ob14}
N 9200 -8090 9200 -8010 {
lab=o14}
N 8980 -8070 8980 -8020 {
lab=ob14}
N 8980 -7960 8980 -7930 {
lab=#net102}
N 8980 -7930 9200 -7930 {
lab=#net102}
N 9200 -7950 9200 -7930 {
lab=#net102}
N 9070 -7930 9070 -7870 {
lab=#net102}
N 9070 -7810 9070 -7780 {
lab=GND}
N 8950 -7840 9030 -7840 {
lab=VDD}
N 8920 -7990 8940 -7990 {
lab=o14}
N 8920 -8090 8920 -7990 {
lab=o14}
N 8920 -8090 9040 -8090 {
lab=o14}
N 9040 -8150 9040 -8090 {
lab=o14}
N 9130 -7980 9160 -7980 {
lab=ob14}
N 9130 -8070 9130 -7980 {
lab=ob14}
N 8880 -8070 8980 -8070 {
lab=ob14}
N 8880 -8290 8880 -8070 {
lab=ob14}
N 8880 -8290 8920 -8290 {
lab=ob14}
N 9200 -8290 9310 -8290 {
lab=o14}
N 9310 -8290 9310 -8060 {
lab=o14}
N 9200 -8060 9310 -8060 {
lab=o14}
N 8760 -8070 8880 -8070 {
lab=ob14}
N 9310 -8060 9400 -8060 {
lab=o14}
N 8730 -8160 8730 -8110 {
lab=rd}
N 9430 -8140 9430 -8100 {
lab=rd}
N 9460 -8060 9530 -8060 {
lab=b14}
N 8640 -8070 8700 -8070 {
lab=blb14}
N 9350 -8130 9350 -8060 {
lab=o14}
N 8820 -8160 8820 -8070 {
lab=ob14}
N 8650 -8600 8650 -8070 {
lab=blb14}
N 8650 -8600 8660 -8600 {
lab=blb14}
N 9510 -8540 9510 -8060 {
lab=b14}
N 8670 -8540 9510 -8540 {
lab=b14}
N 8670 -8740 8670 -8540 {
lab=b14}
N 8490 -8770 8490 -8760 {
lab=blb14}
N 8450 -8770 8450 -8740 {
lab=b14}
N 8250 -8430 8250 -8390 {
lab=#net103}
N 8250 -8160 8250 -8120 {
lab=#net104}
N 8050 -8460 8210 -8460 {
lab=#net105}
N 8050 -8460 8050 -8310 {
lab=#net105}
N 8050 -8310 8050 -7870 {
lab=#net105}
N 8050 -7870 8210 -7870 {
lab=#net105}
N 10290 -8760 10310 -8760 {
lab=blb15}
N 10290 -8740 10320 -8740 {
lab=b15}
N 11060 -8850 11060 -8760 {
lab=q15}
N 11220 -8850 11220 -8760 {
lab=qb15}
N 11100 -8880 11100 -8730 {
lab=qb15}
N 11180 -8880 11180 -8730 {
lab=q15}
N 11060 -8940 11060 -8910 {
lab=VDD}
N 11060 -8940 11220 -8940 {
lab=VDD}
N 11220 -8940 11220 -8910 {
lab=VDD}
N 11060 -8700 11060 -8660 {
lab=GND}
N 11060 -8660 11220 -8660 {
lab=GND}
N 11220 -8700 11220 -8660 {
lab=GND}
N 11140 -8660 11140 -8640 {
lab=GND}
N 11140 -8960 11140 -8940 {
lab=VDD}
N 10910 -8780 11060 -8780 {
lab=q15}
N 11220 -8790 11340 -8790 {
lab=qb15}
N 11100 -8790 11220 -8790 {
lab=qb15}
N 10800 -8780 10850 -8780 {
lab=b15}
N 11400 -8790 11440 -8790 {
lab=blb15}
N 10880 -9000 10880 -8820 {
lab=WL}
N 10880 -9000 11370 -9000 {
lab=WL}
N 11370 -9000 11370 -8830 {
lab=WL}
N 10800 -9000 10880 -9000 {
lab=WL}
N 11060 -8780 11180 -8780 {
lab=q15}
N 11300 -8830 11300 -8790 {
lab=qb15}
N 10970 -8820 10970 -8780 {
lab=q15}
N 10320 -8740 10800 -8740 {
lab=b15}
N 10800 -8780 10800 -8740 {
lab=b15}
N 10310 -8760 10790 -8760 {
lab=blb15}
N 10790 -8760 10790 -8600 {
lab=blb15}
N 10790 -8600 11450 -8600 {
lab=blb15}
N 11450 -8790 11450 -8600 {
lab=blb15}
N 11440 -8790 11450 -8790 {
lab=blb15}
N 10380 -8330 10380 -8220 {
lab=blb15}
N 10300 -8360 10340 -8360 {
lab=d15}
N 10300 -8360 10300 -8190 {
lab=d15}
N 10300 -8190 10340 -8190 {
lab=d15}
N 10380 -7840 10380 -7800 {
lab=#net106}
N 10380 -7740 10380 -7630 {
lab=b15}
N 10380 -7570 10380 -7530 {
lab=#net107}
N 10300 -7770 10340 -7770 {
lab=#net108}
N 10300 -7770 10300 -7600 {
lab=#net108}
N 10300 -7600 10340 -7600 {
lab=#net108}
N 10130 -7500 10340 -7500 {
lab=we}
N 10060 -7500 10130 -7500 {
lab=we}
N 10060 -8300 10060 -7500 {
lab=we}
N 10060 -8310 10060 -8300 {
lab=we}
N 10060 -8310 10120 -8310 {
lab=we}
N 10060 -8090 10340 -8090 {
lab=we}
N 10070 -8280 10070 -8200 {
lab=d15}
N 10070 -8280 10300 -8280 {
lab=d15}
N 10070 -8210 10070 -7680 {
lab=d15}
N 10070 -7680 10100 -7680 {
lab=d15}
N 10160 -7680 10300 -7680 {
lab=#net108}
N 10380 -7470 10380 -7430 {
lab=GND}
N 10380 -8060 10380 -8020 {
lab=GND}
N 10380 -8530 10380 -8490 {
lab=VDD}
N 10380 -7920 10380 -7900 {
lab=VDD}
N 10380 -8280 10540 -8280 {
lab=blb15}
N 10380 -7690 10530 -7690 {
lab=b15}
N 10530 -7690 10540 -7690 {
lab=b15}
N 9980 -8310 10060 -8310 {
lab=we}
N 9980 -7680 10070 -7680 {
lab=d15}
N 10510 -8760 10510 -8280 {
lab=blb15}
N 10520 -8740 10520 -7690 {
lab=b15}
N 9970 -8890 9970 -8800 {
lab=b15}
N 9880 -8890 9970 -8890 {
lab=b15}
N 9970 -8740 9970 -8670 {
lab=blb15}
N 9880 -8670 9970 -8670 {
lab=blb15}
N 9780 -8670 9820 -8670 {
lab=VDD}
N 9780 -8890 9780 -8670 {
lab=VDD}
N 9780 -8890 9820 -8890 {
lab=VDD}
N 9930 -8770 9930 -8600 {
lab=p_b}
N 9780 -8670 9780 -8590 {
lab=VDD}
N 9970 -8890 10040 -8890 {
lab=b15}
N 9850 -8850 9850 -8710 {
lab=p_b}
N 9850 -8740 9930 -8740 {
lab=p_b}
N 10190 -8760 10290 -8760 {
lab=blb15}
N 10190 -8760 10190 -8680 {
lab=blb15}
N 9970 -8680 10190 -8680 {
lab=blb15}
N 10040 -8740 10290 -8740 {
lab=b15}
N 10040 -8890 10040 -8740 {
lab=b15}
N 11240 -8290 11330 -8290 {
lab=o15}
N 11330 -8380 11330 -8290 {
lab=o15}
N 11110 -8290 11180 -8290 {
lab=ob15}
N 11110 -8380 11110 -8290 {
lab=ob15}
N 11110 -8480 11110 -8440 {
lab=VDD}
N 11110 -8480 11330 -8480 {
lab=VDD}
N 11330 -8480 11330 -8440 {
lab=VDD}
N 11040 -8330 11210 -8330 {
lab=p_b}
N 11030 -8480 11110 -8480 {
lab=VDD}
N 11040 -8290 11110 -8290 {
lab=ob15}
N 11150 -8410 11290 -8410 {
lab=p_b}
N 11180 -8410 11180 -8330 {
lab=p_b}
N 11330 -8190 11330 -8170 {
lab=VDD}
N 11110 -8190 11330 -8190 {
lab=VDD}
N 11110 -8190 11110 -8180 {
lab=VDD}
N 11150 -8150 11250 -8150 {
lab=o15}
N 11250 -8150 11250 -8090 {
lab=o15}
N 11250 -8090 11330 -8090 {
lab=o15}
N 11330 -8110 11330 -8090 {
lab=o15}
N 11370 -8140 11400 -8140 {
lab=ob15}
N 11400 -8140 11400 -8070 {
lab=ob15}
N 11110 -8070 11400 -8070 {
lab=ob15}
N 11110 -8120 11110 -8070 {
lab=ob15}
N 11330 -8090 11330 -8010 {
lab=o15}
N 11110 -8070 11110 -8020 {
lab=ob15}
N 11110 -7960 11110 -7930 {
lab=#net109}
N 11110 -7930 11330 -7930 {
lab=#net109}
N 11330 -7950 11330 -7930 {
lab=#net109}
N 11200 -7930 11200 -7870 {
lab=#net109}
N 11200 -7810 11200 -7780 {
lab=GND}
N 11080 -7840 11160 -7840 {
lab=VDD}
N 11050 -7990 11070 -7990 {
lab=o15}
N 11050 -8090 11050 -7990 {
lab=o15}
N 11050 -8090 11170 -8090 {
lab=o15}
N 11170 -8150 11170 -8090 {
lab=o15}
N 11260 -7980 11290 -7980 {
lab=ob15}
N 11260 -8070 11260 -7980 {
lab=ob15}
N 11010 -8070 11110 -8070 {
lab=ob15}
N 11010 -8290 11010 -8070 {
lab=ob15}
N 11010 -8290 11050 -8290 {
lab=ob15}
N 11330 -8290 11440 -8290 {
lab=o15}
N 11440 -8290 11440 -8060 {
lab=o15}
N 11330 -8060 11440 -8060 {
lab=o15}
N 10890 -8070 11010 -8070 {
lab=ob15}
N 11440 -8060 11530 -8060 {
lab=o15}
N 10860 -8160 10860 -8110 {
lab=rd}
N 11560 -8140 11560 -8100 {
lab=rd}
N 11590 -8060 11660 -8060 {
lab=b15}
N 10770 -8070 10830 -8070 {
lab=blb15}
N 11480 -8130 11480 -8060 {
lab=o15}
N 10950 -8160 10950 -8070 {
lab=ob15}
N 10780 -8600 10780 -8070 {
lab=blb15}
N 10780 -8600 10790 -8600 {
lab=blb15}
N 11640 -8540 11640 -8060 {
lab=b15}
N 10800 -8540 11640 -8540 {
lab=b15}
N 10800 -8740 10800 -8540 {
lab=b15}
N 10620 -8770 10620 -8760 {
lab=blb15}
N 10580 -8770 10580 -8740 {
lab=b15}
N 10380 -8430 10380 -8390 {
lab=#net110}
N 10380 -8160 10380 -8120 {
lab=#net111}
N 10180 -8460 10340 -8460 {
lab=#net112}
N 10180 -8460 10180 -8310 {
lab=#net112}
N 10180 -8310 10180 -7870 {
lab=#net112}
N 10180 -7870 10340 -7870 {
lab=#net112}
N 12610 -8740 12630 -8740 {
lab=blb16}
N 12610 -8720 12640 -8720 {
lab=b16}
N 13380 -8830 13380 -8740 {
lab=q16}
N 13540 -8830 13540 -8740 {
lab=qb16}
N 13420 -8860 13420 -8710 {
lab=qb16}
N 13500 -8860 13500 -8710 {
lab=q16}
N 13380 -8920 13380 -8890 {
lab=VDD}
N 13380 -8920 13540 -8920 {
lab=VDD}
N 13540 -8920 13540 -8890 {
lab=VDD}
N 13380 -8680 13380 -8640 {
lab=GND}
N 13380 -8640 13540 -8640 {
lab=GND}
N 13540 -8680 13540 -8640 {
lab=GND}
N 13460 -8640 13460 -8620 {
lab=GND}
N 13460 -8940 13460 -8920 {
lab=VDD}
N 13230 -8760 13380 -8760 {
lab=q16}
N 13540 -8770 13660 -8770 {
lab=qb16}
N 13420 -8770 13540 -8770 {
lab=qb16}
N 13120 -8760 13170 -8760 {
lab=b16}
N 13720 -8770 13760 -8770 {
lab=blb16}
N 13200 -8980 13200 -8800 {
lab=WL}
N 13200 -8980 13690 -8980 {
lab=WL}
N 13690 -8980 13690 -8810 {
lab=WL}
N 13120 -8980 13200 -8980 {
lab=WL}
N 13380 -8760 13500 -8760 {
lab=q16}
N 13620 -8810 13620 -8770 {
lab=qb16}
N 13290 -8800 13290 -8760 {
lab=q16}
N 12640 -8720 13120 -8720 {
lab=b16}
N 13120 -8760 13120 -8720 {
lab=b16}
N 12630 -8740 13110 -8740 {
lab=blb16}
N 13110 -8740 13110 -8580 {
lab=blb16}
N 13110 -8580 13770 -8580 {
lab=blb16}
N 13770 -8770 13770 -8580 {
lab=blb16}
N 13760 -8770 13770 -8770 {
lab=blb16}
N 12700 -8310 12700 -8200 {
lab=blb16}
N 12620 -8340 12660 -8340 {
lab=d16}
N 12620 -8340 12620 -8170 {
lab=d16}
N 12620 -8170 12660 -8170 {
lab=d16}
N 12700 -7820 12700 -7780 {
lab=#net113}
N 12700 -7720 12700 -7610 {
lab=b16}
N 12700 -7550 12700 -7510 {
lab=#net114}
N 12620 -7750 12660 -7750 {
lab=#net115}
N 12620 -7750 12620 -7580 {
lab=#net115}
N 12620 -7580 12660 -7580 {
lab=#net115}
N 12450 -7480 12660 -7480 {
lab=we}
N 12380 -7480 12450 -7480 {
lab=we}
N 12380 -8280 12380 -7480 {
lab=we}
N 12380 -8290 12380 -8280 {
lab=we}
N 12380 -8290 12440 -8290 {
lab=we}
N 12380 -8070 12660 -8070 {
lab=we}
N 12390 -8260 12390 -8180 {
lab=d16}
N 12390 -8260 12620 -8260 {
lab=d16}
N 12390 -8190 12390 -7660 {
lab=d16}
N 12390 -7660 12420 -7660 {
lab=d16}
N 12480 -7660 12620 -7660 {
lab=#net115}
N 12700 -7450 12700 -7410 {
lab=GND}
N 12700 -8040 12700 -8000 {
lab=GND}
N 12700 -8510 12700 -8470 {
lab=VDD}
N 12700 -7900 12700 -7880 {
lab=VDD}
N 12700 -8260 12860 -8260 {
lab=blb16}
N 12700 -7670 12850 -7670 {
lab=b16}
N 12850 -7670 12860 -7670 {
lab=b16}
N 12300 -8290 12380 -8290 {
lab=we}
N 12300 -7660 12390 -7660 {
lab=d16}
N 12830 -8740 12830 -8260 {
lab=blb16}
N 12840 -8720 12840 -7670 {
lab=b16}
N 12290 -8870 12290 -8780 {
lab=b16}
N 12200 -8870 12290 -8870 {
lab=b16}
N 12290 -8720 12290 -8650 {
lab=blb16}
N 12200 -8650 12290 -8650 {
lab=blb16}
N 12100 -8650 12140 -8650 {
lab=VDD}
N 12100 -8870 12100 -8650 {
lab=VDD}
N 12100 -8870 12140 -8870 {
lab=VDD}
N 12250 -8750 12250 -8580 {
lab=p_b}
N 12100 -8650 12100 -8570 {
lab=VDD}
N 12290 -8870 12360 -8870 {
lab=b16}
N 12170 -8830 12170 -8690 {
lab=p_b}
N 12170 -8720 12250 -8720 {
lab=p_b}
N 12510 -8740 12610 -8740 {
lab=blb16}
N 12510 -8740 12510 -8660 {
lab=blb16}
N 12290 -8660 12510 -8660 {
lab=blb16}
N 12360 -8720 12610 -8720 {
lab=b16}
N 12360 -8870 12360 -8720 {
lab=b16}
N 13560 -8270 13650 -8270 {
lab=o16}
N 13650 -8360 13650 -8270 {
lab=o16}
N 13430 -8270 13500 -8270 {
lab=ob16}
N 13430 -8360 13430 -8270 {
lab=ob16}
N 13430 -8460 13430 -8420 {
lab=VDD}
N 13430 -8460 13650 -8460 {
lab=VDD}
N 13650 -8460 13650 -8420 {
lab=VDD}
N 13360 -8310 13530 -8310 {
lab=p_b}
N 13350 -8460 13430 -8460 {
lab=VDD}
N 13360 -8270 13430 -8270 {
lab=ob16}
N 13470 -8390 13610 -8390 {
lab=p_b}
N 13500 -8390 13500 -8310 {
lab=p_b}
N 13650 -8170 13650 -8150 {
lab=VDD}
N 13430 -8170 13650 -8170 {
lab=VDD}
N 13430 -8170 13430 -8160 {
lab=VDD}
N 13470 -8130 13570 -8130 {
lab=o16}
N 13570 -8130 13570 -8070 {
lab=o16}
N 13570 -8070 13650 -8070 {
lab=o16}
N 13650 -8090 13650 -8070 {
lab=o16}
N 13690 -8120 13720 -8120 {
lab=ob16}
N 13720 -8120 13720 -8050 {
lab=ob16}
N 13430 -8050 13720 -8050 {
lab=ob16}
N 13430 -8100 13430 -8050 {
lab=ob16}
N 13650 -8070 13650 -7990 {
lab=o16}
N 13430 -8050 13430 -8000 {
lab=ob16}
N 13430 -7940 13430 -7910 {
lab=#net116}
N 13430 -7910 13650 -7910 {
lab=#net116}
N 13650 -7930 13650 -7910 {
lab=#net116}
N 13520 -7910 13520 -7850 {
lab=#net116}
N 13520 -7790 13520 -7760 {
lab=GND}
N 13400 -7820 13480 -7820 {
lab=VDD}
N 13370 -7970 13390 -7970 {
lab=o16}
N 13370 -8070 13370 -7970 {
lab=o16}
N 13370 -8070 13490 -8070 {
lab=o16}
N 13490 -8130 13490 -8070 {
lab=o16}
N 13580 -7960 13610 -7960 {
lab=ob16}
N 13580 -8050 13580 -7960 {
lab=ob16}
N 13330 -8050 13430 -8050 {
lab=ob16}
N 13330 -8270 13330 -8050 {
lab=ob16}
N 13330 -8270 13370 -8270 {
lab=ob16}
N 13650 -8270 13760 -8270 {
lab=o16}
N 13760 -8270 13760 -8040 {
lab=o16}
N 13650 -8040 13760 -8040 {
lab=o16}
N 13210 -8050 13330 -8050 {
lab=ob16}
N 13760 -8040 13850 -8040 {
lab=o16}
N 13180 -8140 13180 -8090 {
lab=rd}
N 13880 -8120 13880 -8080 {
lab=rd}
N 13910 -8040 13980 -8040 {
lab=b16}
N 13090 -8050 13150 -8050 {
lab=blb16}
N 13800 -8110 13800 -8040 {
lab=o16}
N 13270 -8140 13270 -8050 {
lab=ob16}
N 13100 -8580 13100 -8050 {
lab=blb16}
N 13100 -8580 13110 -8580 {
lab=blb16}
N 13960 -8520 13960 -8040 {
lab=b16}
N 13120 -8520 13960 -8520 {
lab=b16}
N 13120 -8720 13120 -8520 {
lab=b16}
N 12940 -8750 12940 -8740 {
lab=blb16}
N 12900 -8750 12900 -8720 {
lab=b16}
N 12700 -8410 12700 -8370 {
lab=#net117}
N 12700 -8140 12700 -8100 {
lab=#net118}
N 12500 -8440 12660 -8440 {
lab=#net119}
N 12500 -8440 12500 -8290 {
lab=#net119}
N 12500 -8290 12500 -7850 {
lab=#net119}
N 12500 -7850 12660 -7850 {
lab=#net119}
N 14760 -8730 14780 -8730 {
lab=blb17}
N 14760 -8710 14790 -8710 {
lab=b17}
N 15530 -8820 15530 -8730 {
lab=q17}
N 15690 -8820 15690 -8730 {
lab=qb17}
N 15570 -8850 15570 -8700 {
lab=qb17}
N 15650 -8850 15650 -8700 {
lab=q17}
N 15530 -8910 15530 -8880 {
lab=VDD}
N 15530 -8910 15690 -8910 {
lab=VDD}
N 15690 -8910 15690 -8880 {
lab=VDD}
N 15530 -8670 15530 -8630 {
lab=GND}
N 15530 -8630 15690 -8630 {
lab=GND}
N 15690 -8670 15690 -8630 {
lab=GND}
N 15610 -8630 15610 -8610 {
lab=GND}
N 15610 -8930 15610 -8910 {
lab=VDD}
N 15380 -8750 15530 -8750 {
lab=q17}
N 15690 -8760 15810 -8760 {
lab=qb17}
N 15570 -8760 15690 -8760 {
lab=qb17}
N 15270 -8750 15320 -8750 {
lab=b17}
N 15870 -8760 15910 -8760 {
lab=blb17}
N 15350 -8970 15350 -8790 {
lab=WL}
N 15350 -8970 15840 -8970 {
lab=WL}
N 15840 -8970 15840 -8800 {
lab=WL}
N 15270 -8970 15350 -8970 {
lab=WL}
N 15530 -8750 15650 -8750 {
lab=q17}
N 15770 -8800 15770 -8760 {
lab=qb17}
N 15440 -8790 15440 -8750 {
lab=q17}
N 14790 -8710 15270 -8710 {
lab=b17}
N 15270 -8750 15270 -8710 {
lab=b17}
N 14780 -8730 15260 -8730 {
lab=blb17}
N 15260 -8730 15260 -8570 {
lab=blb17}
N 15260 -8570 15920 -8570 {
lab=blb17}
N 15920 -8760 15920 -8570 {
lab=blb17}
N 15910 -8760 15920 -8760 {
lab=blb17}
N 14850 -8300 14850 -8190 {
lab=blb17}
N 14770 -8330 14810 -8330 {
lab=d17}
N 14770 -8330 14770 -8160 {
lab=d17}
N 14770 -8160 14810 -8160 {
lab=d17}
N 14850 -7810 14850 -7770 {
lab=#net120}
N 14850 -7710 14850 -7600 {
lab=b17}
N 14850 -7540 14850 -7500 {
lab=#net121}
N 14770 -7740 14810 -7740 {
lab=#net122}
N 14770 -7740 14770 -7570 {
lab=#net122}
N 14770 -7570 14810 -7570 {
lab=#net122}
N 14600 -7470 14810 -7470 {
lab=we}
N 14530 -7470 14600 -7470 {
lab=we}
N 14530 -8270 14530 -7470 {
lab=we}
N 14530 -8280 14530 -8270 {
lab=we}
N 14530 -8280 14590 -8280 {
lab=we}
N 14530 -8060 14810 -8060 {
lab=we}
N 14540 -8250 14540 -8170 {
lab=d17}
N 14540 -8250 14770 -8250 {
lab=d17}
N 14540 -8180 14540 -7650 {
lab=d17}
N 14540 -7650 14570 -7650 {
lab=d17}
N 14630 -7650 14770 -7650 {
lab=#net122}
N 14850 -7440 14850 -7400 {
lab=GND}
N 14850 -8030 14850 -7990 {
lab=GND}
N 14850 -8500 14850 -8460 {
lab=VDD}
N 14850 -7890 14850 -7870 {
lab=VDD}
N 14850 -8250 15010 -8250 {
lab=blb17}
N 14850 -7660 15000 -7660 {
lab=b17}
N 15000 -7660 15010 -7660 {
lab=b17}
N 14450 -8280 14530 -8280 {
lab=we}
N 14450 -7650 14540 -7650 {
lab=d17}
N 14980 -8730 14980 -8250 {
lab=blb17}
N 14990 -8710 14990 -7660 {
lab=b17}
N 14440 -8860 14440 -8770 {
lab=b17}
N 14350 -8860 14440 -8860 {
lab=b17}
N 14440 -8710 14440 -8640 {
lab=blb17}
N 14350 -8640 14440 -8640 {
lab=blb17}
N 14250 -8640 14290 -8640 {
lab=VDD}
N 14250 -8860 14250 -8640 {
lab=VDD}
N 14250 -8860 14290 -8860 {
lab=VDD}
N 14400 -8740 14400 -8570 {
lab=p_b}
N 14250 -8640 14250 -8560 {
lab=VDD}
N 14440 -8860 14510 -8860 {
lab=b17}
N 14320 -8820 14320 -8680 {
lab=p_b}
N 14320 -8710 14400 -8710 {
lab=p_b}
N 14660 -8730 14760 -8730 {
lab=blb17}
N 14660 -8730 14660 -8650 {
lab=blb17}
N 14440 -8650 14660 -8650 {
lab=blb17}
N 14510 -8710 14760 -8710 {
lab=b17}
N 14510 -8860 14510 -8710 {
lab=b17}
N 15710 -8260 15800 -8260 {
lab=o17}
N 15800 -8350 15800 -8260 {
lab=o17}
N 15580 -8260 15650 -8260 {
lab=ob17}
N 15580 -8350 15580 -8260 {
lab=ob17}
N 15580 -8450 15580 -8410 {
lab=VDD}
N 15580 -8450 15800 -8450 {
lab=VDD}
N 15800 -8450 15800 -8410 {
lab=VDD}
N 15510 -8300 15680 -8300 {
lab=p_b}
N 15500 -8450 15580 -8450 {
lab=VDD}
N 15510 -8260 15580 -8260 {
lab=ob17}
N 15620 -8380 15760 -8380 {
lab=p_b}
N 15650 -8380 15650 -8300 {
lab=p_b}
N 15800 -8160 15800 -8140 {
lab=VDD}
N 15580 -8160 15800 -8160 {
lab=VDD}
N 15580 -8160 15580 -8150 {
lab=VDD}
N 15620 -8120 15720 -8120 {
lab=o17}
N 15720 -8120 15720 -8060 {
lab=o17}
N 15720 -8060 15800 -8060 {
lab=o17}
N 15800 -8080 15800 -8060 {
lab=o17}
N 15840 -8110 15870 -8110 {
lab=ob17}
N 15870 -8110 15870 -8040 {
lab=ob17}
N 15580 -8040 15870 -8040 {
lab=ob17}
N 15580 -8090 15580 -8040 {
lab=ob17}
N 15800 -8060 15800 -7980 {
lab=o17}
N 15580 -8040 15580 -7990 {
lab=ob17}
N 15580 -7930 15580 -7900 {
lab=#net123}
N 15580 -7900 15800 -7900 {
lab=#net123}
N 15800 -7920 15800 -7900 {
lab=#net123}
N 15670 -7900 15670 -7840 {
lab=#net123}
N 15670 -7780 15670 -7750 {
lab=GND}
N 15550 -7810 15630 -7810 {
lab=VDD}
N 15520 -7960 15540 -7960 {
lab=o17}
N 15520 -8060 15520 -7960 {
lab=o17}
N 15520 -8060 15640 -8060 {
lab=o17}
N 15640 -8120 15640 -8060 {
lab=o17}
N 15730 -7950 15760 -7950 {
lab=ob17}
N 15730 -8040 15730 -7950 {
lab=ob17}
N 15480 -8040 15580 -8040 {
lab=ob17}
N 15480 -8260 15480 -8040 {
lab=ob17}
N 15480 -8260 15520 -8260 {
lab=ob17}
N 15800 -8260 15910 -8260 {
lab=o17}
N 15910 -8260 15910 -8030 {
lab=o17}
N 15800 -8030 15910 -8030 {
lab=o17}
N 15360 -8040 15480 -8040 {
lab=ob17}
N 15910 -8030 16000 -8030 {
lab=o17}
N 15330 -8130 15330 -8080 {
lab=rd}
N 16030 -8110 16030 -8070 {
lab=rd}
N 16060 -8030 16130 -8030 {
lab=b17}
N 15240 -8040 15300 -8040 {
lab=blb17}
N 15950 -8100 15950 -8030 {
lab=o17}
N 15420 -8130 15420 -8040 {
lab=ob17}
N 15250 -8570 15250 -8040 {
lab=blb17}
N 15250 -8570 15260 -8570 {
lab=blb17}
N 16110 -8510 16110 -8030 {
lab=b17}
N 15270 -8510 16110 -8510 {
lab=b17}
N 15270 -8710 15270 -8510 {
lab=b17}
N 15090 -8740 15090 -8730 {
lab=blb17}
N 15050 -8740 15050 -8710 {
lab=b17}
N 14850 -8400 14850 -8360 {
lab=#net124}
N 14850 -8130 14850 -8090 {
lab=#net125}
N 14650 -8430 14810 -8430 {
lab=#net126}
N 14650 -8430 14650 -8280 {
lab=#net126}
N 14650 -8280 14650 -7840 {
lab=#net126}
N 14650 -7840 14810 -7840 {
lab=#net126}
N 3780 -6460 3800 -6460 {
lab=blb18}
N 3780 -6440 3810 -6440 {
lab=b18}
N 4550 -6550 4550 -6460 {
lab=q18}
N 4710 -6550 4710 -6460 {
lab=qb18}
N 4590 -6580 4590 -6430 {
lab=qb18}
N 4670 -6580 4670 -6430 {
lab=q18}
N 4550 -6640 4550 -6610 {
lab=VDD}
N 4550 -6640 4710 -6640 {
lab=VDD}
N 4710 -6640 4710 -6610 {
lab=VDD}
N 4550 -6400 4550 -6360 {
lab=GND}
N 4550 -6360 4710 -6360 {
lab=GND}
N 4710 -6400 4710 -6360 {
lab=GND}
N 4630 -6360 4630 -6340 {
lab=GND}
N 4630 -6660 4630 -6640 {
lab=VDD}
N 4400 -6480 4550 -6480 {
lab=q18}
N 4710 -6490 4830 -6490 {
lab=qb18}
N 4590 -6490 4710 -6490 {
lab=qb18}
N 4290 -6480 4340 -6480 {
lab=b18}
N 4890 -6490 4930 -6490 {
lab=blb18}
N 4370 -6700 4370 -6520 {
lab=WL}
N 4370 -6700 4860 -6700 {
lab=WL}
N 4860 -6700 4860 -6530 {
lab=WL}
N 4290 -6700 4370 -6700 {
lab=WL}
N 4550 -6480 4670 -6480 {
lab=q18}
N 4790 -6530 4790 -6490 {
lab=qb18}
N 4460 -6520 4460 -6480 {
lab=q18}
N 3810 -6440 4290 -6440 {
lab=b18}
N 4290 -6480 4290 -6440 {
lab=b18}
N 3800 -6460 4280 -6460 {
lab=blb18}
N 4280 -6460 4280 -6300 {
lab=blb18}
N 4280 -6300 4940 -6300 {
lab=blb18}
N 4940 -6490 4940 -6300 {
lab=blb18}
N 4930 -6490 4940 -6490 {
lab=blb18}
N 3870 -6030 3870 -5920 {
lab=blb18}
N 3790 -6060 3830 -6060 {
lab=d18}
N 3790 -6060 3790 -5890 {
lab=d18}
N 3790 -5890 3830 -5890 {
lab=d18}
N 3870 -5540 3870 -5500 {
lab=#net127}
N 3870 -5440 3870 -5330 {
lab=b18}
N 3870 -5270 3870 -5230 {
lab=#net128}
N 3790 -5470 3830 -5470 {
lab=#net129}
N 3790 -5470 3790 -5300 {
lab=#net129}
N 3790 -5300 3830 -5300 {
lab=#net129}
N 3620 -5200 3830 -5200 {
lab=we}
N 3550 -5200 3620 -5200 {
lab=we}
N 3550 -6000 3550 -5200 {
lab=we}
N 3550 -6010 3550 -6000 {
lab=we}
N 3550 -6010 3610 -6010 {
lab=we}
N 3550 -5790 3830 -5790 {
lab=we}
N 3560 -5980 3560 -5900 {
lab=d18}
N 3560 -5980 3790 -5980 {
lab=d18}
N 3560 -5910 3560 -5380 {
lab=d18}
N 3560 -5380 3590 -5380 {
lab=d18}
N 3650 -5380 3790 -5380 {
lab=#net129}
N 3870 -5170 3870 -5130 {
lab=GND}
N 3870 -5760 3870 -5720 {
lab=GND}
N 3870 -6230 3870 -6190 {
lab=VDD}
N 3870 -5620 3870 -5600 {
lab=VDD}
N 3870 -5980 4030 -5980 {
lab=blb18}
N 3870 -5390 4020 -5390 {
lab=b18}
N 4020 -5390 4030 -5390 {
lab=b18}
N 3470 -6010 3550 -6010 {
lab=we}
N 3470 -5380 3560 -5380 {
lab=d18}
N 4000 -6460 4000 -5980 {
lab=blb18}
N 4010 -6440 4010 -5390 {
lab=b18}
N 3460 -6590 3460 -6500 {
lab=b18}
N 3370 -6590 3460 -6590 {
lab=b18}
N 3460 -6440 3460 -6370 {
lab=blb18}
N 3370 -6370 3460 -6370 {
lab=blb18}
N 3270 -6370 3310 -6370 {
lab=VDD}
N 3270 -6590 3270 -6370 {
lab=VDD}
N 3270 -6590 3310 -6590 {
lab=VDD}
N 3420 -6470 3420 -6300 {
lab=p_b}
N 3270 -6370 3270 -6290 {
lab=VDD}
N 3460 -6590 3530 -6590 {
lab=b18}
N 3340 -6550 3340 -6410 {
lab=p_b}
N 3340 -6440 3420 -6440 {
lab=p_b}
N 3680 -6460 3780 -6460 {
lab=blb18}
N 3680 -6460 3680 -6380 {
lab=blb18}
N 3460 -6380 3680 -6380 {
lab=blb18}
N 3530 -6440 3780 -6440 {
lab=b18}
N 3530 -6590 3530 -6440 {
lab=b18}
N 4730 -5990 4820 -5990 {
lab=o18}
N 4820 -6080 4820 -5990 {
lab=o18}
N 4600 -5990 4670 -5990 {
lab=ob18}
N 4600 -6080 4600 -5990 {
lab=ob18}
N 4600 -6180 4600 -6140 {
lab=VDD}
N 4600 -6180 4820 -6180 {
lab=VDD}
N 4820 -6180 4820 -6140 {
lab=VDD}
N 4530 -6030 4700 -6030 {
lab=p_b}
N 4520 -6180 4600 -6180 {
lab=VDD}
N 4530 -5990 4600 -5990 {
lab=ob18}
N 4640 -6110 4780 -6110 {
lab=p_b}
N 4670 -6110 4670 -6030 {
lab=p_b}
N 4820 -5890 4820 -5870 {
lab=VDD}
N 4600 -5890 4820 -5890 {
lab=VDD}
N 4600 -5890 4600 -5880 {
lab=VDD}
N 4640 -5850 4740 -5850 {
lab=o18}
N 4740 -5850 4740 -5790 {
lab=o18}
N 4740 -5790 4820 -5790 {
lab=o18}
N 4820 -5810 4820 -5790 {
lab=o18}
N 4860 -5840 4890 -5840 {
lab=ob18}
N 4890 -5840 4890 -5770 {
lab=ob18}
N 4600 -5770 4890 -5770 {
lab=ob18}
N 4600 -5820 4600 -5770 {
lab=ob18}
N 4820 -5790 4820 -5710 {
lab=o18}
N 4600 -5770 4600 -5720 {
lab=ob18}
N 4600 -5660 4600 -5630 {
lab=#net130}
N 4600 -5630 4820 -5630 {
lab=#net130}
N 4820 -5650 4820 -5630 {
lab=#net130}
N 4690 -5630 4690 -5570 {
lab=#net130}
N 4690 -5510 4690 -5480 {
lab=GND}
N 4570 -5540 4650 -5540 {
lab=VDD}
N 4540 -5690 4560 -5690 {
lab=o18}
N 4540 -5790 4540 -5690 {
lab=o18}
N 4540 -5790 4660 -5790 {
lab=o18}
N 4660 -5850 4660 -5790 {
lab=o18}
N 4750 -5680 4780 -5680 {
lab=ob18}
N 4750 -5770 4750 -5680 {
lab=ob18}
N 4500 -5770 4600 -5770 {
lab=ob18}
N 4500 -5990 4500 -5770 {
lab=ob18}
N 4500 -5990 4540 -5990 {
lab=ob18}
N 4820 -5990 4930 -5990 {
lab=o18}
N 4930 -5990 4930 -5760 {
lab=o18}
N 4820 -5760 4930 -5760 {
lab=o18}
N 4380 -5770 4500 -5770 {
lab=ob18}
N 4930 -5760 5020 -5760 {
lab=o18}
N 4350 -5860 4350 -5810 {
lab=rd}
N 5050 -5840 5050 -5800 {
lab=rd}
N 5080 -5760 5150 -5760 {
lab=b18}
N 4260 -5770 4320 -5770 {
lab=blb18}
N 4970 -5830 4970 -5760 {
lab=o18}
N 4440 -5860 4440 -5770 {
lab=ob18}
N 4270 -6300 4270 -5770 {
lab=blb18}
N 4270 -6300 4280 -6300 {
lab=blb18}
N 5130 -6240 5130 -5760 {
lab=b18}
N 4290 -6240 5130 -6240 {
lab=b18}
N 4290 -6440 4290 -6240 {
lab=b18}
N 4110 -6470 4110 -6460 {
lab=blb18}
N 4070 -6470 4070 -6440 {
lab=b18}
N 3870 -6130 3870 -6090 {
lab=#net131}
N 3870 -5860 3870 -5820 {
lab=#net132}
N 3670 -6160 3830 -6160 {
lab=#net133}
N 3670 -6160 3670 -6010 {
lab=#net133}
N 3670 -6010 3670 -5570 {
lab=#net133}
N 3670 -5570 3830 -5570 {
lab=#net133}
N 6100 -6440 6120 -6440 {
lab=blb19}
N 6100 -6420 6130 -6420 {
lab=b19}
N 6870 -6530 6870 -6440 {
lab=q19}
N 7030 -6530 7030 -6440 {
lab=qb19}
N 6910 -6560 6910 -6410 {
lab=qb19}
N 6990 -6560 6990 -6410 {
lab=q19}
N 6870 -6620 6870 -6590 {
lab=VDD}
N 6870 -6620 7030 -6620 {
lab=VDD}
N 7030 -6620 7030 -6590 {
lab=VDD}
N 6870 -6380 6870 -6340 {
lab=GND}
N 6870 -6340 7030 -6340 {
lab=GND}
N 7030 -6380 7030 -6340 {
lab=GND}
N 6950 -6340 6950 -6320 {
lab=GND}
N 6950 -6640 6950 -6620 {
lab=VDD}
N 6720 -6460 6870 -6460 {
lab=q19}
N 7030 -6470 7150 -6470 {
lab=qb19}
N 6910 -6470 7030 -6470 {
lab=qb19}
N 6610 -6460 6660 -6460 {
lab=b19}
N 7210 -6470 7250 -6470 {
lab=blb19}
N 6690 -6680 6690 -6500 {
lab=WL}
N 6690 -6680 7180 -6680 {
lab=WL}
N 7180 -6680 7180 -6510 {
lab=WL}
N 6610 -6680 6690 -6680 {
lab=WL}
N 6870 -6460 6990 -6460 {
lab=q19}
N 7110 -6510 7110 -6470 {
lab=qb19}
N 6780 -6500 6780 -6460 {
lab=q19}
N 6130 -6420 6610 -6420 {
lab=b19}
N 6610 -6460 6610 -6420 {
lab=b19}
N 6120 -6440 6600 -6440 {
lab=blb19}
N 6600 -6440 6600 -6280 {
lab=blb19}
N 6600 -6280 7260 -6280 {
lab=blb19}
N 7260 -6470 7260 -6280 {
lab=blb19}
N 7250 -6470 7260 -6470 {
lab=blb19}
N 6190 -6010 6190 -5900 {
lab=blb19}
N 6110 -6040 6150 -6040 {
lab=d19}
N 6110 -6040 6110 -5870 {
lab=d19}
N 6110 -5870 6150 -5870 {
lab=d19}
N 6190 -5520 6190 -5480 {
lab=#net134}
N 6190 -5420 6190 -5310 {
lab=b19}
N 6190 -5250 6190 -5210 {
lab=#net135}
N 6110 -5450 6150 -5450 {
lab=#net136}
N 6110 -5450 6110 -5280 {
lab=#net136}
N 6110 -5280 6150 -5280 {
lab=#net136}
N 5940 -5180 6150 -5180 {
lab=we}
N 5870 -5180 5940 -5180 {
lab=we}
N 5870 -5980 5870 -5180 {
lab=we}
N 5870 -5990 5870 -5980 {
lab=we}
N 5870 -5990 5930 -5990 {
lab=we}
N 5870 -5770 6150 -5770 {
lab=we}
N 5880 -5960 5880 -5880 {
lab=d19}
N 5880 -5960 6110 -5960 {
lab=d19}
N 5880 -5890 5880 -5360 {
lab=d19}
N 5880 -5360 5910 -5360 {
lab=d19}
N 5970 -5360 6110 -5360 {
lab=#net136}
N 6190 -5150 6190 -5110 {
lab=GND}
N 6190 -5740 6190 -5700 {
lab=GND}
N 6190 -6210 6190 -6170 {
lab=VDD}
N 6190 -5600 6190 -5580 {
lab=VDD}
N 6190 -5960 6350 -5960 {
lab=blb19}
N 6190 -5370 6340 -5370 {
lab=b19}
N 6340 -5370 6350 -5370 {
lab=b19}
N 5790 -5990 5870 -5990 {
lab=we}
N 5790 -5360 5880 -5360 {
lab=d19}
N 6320 -6440 6320 -5960 {
lab=blb19}
N 6330 -6420 6330 -5370 {
lab=b19}
N 5780 -6570 5780 -6480 {
lab=b19}
N 5690 -6570 5780 -6570 {
lab=b19}
N 5780 -6420 5780 -6350 {
lab=blb19}
N 5690 -6350 5780 -6350 {
lab=blb19}
N 5590 -6350 5630 -6350 {
lab=VDD}
N 5590 -6570 5590 -6350 {
lab=VDD}
N 5590 -6570 5630 -6570 {
lab=VDD}
N 5740 -6450 5740 -6280 {
lab=p_b}
N 5590 -6350 5590 -6270 {
lab=VDD}
N 5780 -6570 5850 -6570 {
lab=b19}
N 5660 -6530 5660 -6390 {
lab=p_b}
N 5660 -6420 5740 -6420 {
lab=p_b}
N 6000 -6440 6100 -6440 {
lab=blb19}
N 6000 -6440 6000 -6360 {
lab=blb19}
N 5780 -6360 6000 -6360 {
lab=blb19}
N 5850 -6420 6100 -6420 {
lab=b19}
N 5850 -6570 5850 -6420 {
lab=b19}
N 7050 -5970 7140 -5970 {
lab=o19}
N 7140 -6060 7140 -5970 {
lab=o19}
N 6920 -5970 6990 -5970 {
lab=ob19}
N 6920 -6060 6920 -5970 {
lab=ob19}
N 6920 -6160 6920 -6120 {
lab=VDD}
N 6920 -6160 7140 -6160 {
lab=VDD}
N 7140 -6160 7140 -6120 {
lab=VDD}
N 6850 -6010 7020 -6010 {
lab=p_b}
N 6840 -6160 6920 -6160 {
lab=VDD}
N 6850 -5970 6920 -5970 {
lab=ob19}
N 6960 -6090 7100 -6090 {
lab=p_b}
N 6990 -6090 6990 -6010 {
lab=p_b}
N 7140 -5870 7140 -5850 {
lab=VDD}
N 6920 -5870 7140 -5870 {
lab=VDD}
N 6920 -5870 6920 -5860 {
lab=VDD}
N 6960 -5830 7060 -5830 {
lab=o19}
N 7060 -5830 7060 -5770 {
lab=o19}
N 7060 -5770 7140 -5770 {
lab=o19}
N 7140 -5790 7140 -5770 {
lab=o19}
N 7180 -5820 7210 -5820 {
lab=ob19}
N 7210 -5820 7210 -5750 {
lab=ob19}
N 6920 -5750 7210 -5750 {
lab=ob19}
N 6920 -5800 6920 -5750 {
lab=ob19}
N 7140 -5770 7140 -5690 {
lab=o19}
N 6920 -5750 6920 -5700 {
lab=ob19}
N 6920 -5640 6920 -5610 {
lab=#net137}
N 6920 -5610 7140 -5610 {
lab=#net137}
N 7140 -5630 7140 -5610 {
lab=#net137}
N 7010 -5610 7010 -5550 {
lab=#net137}
N 7010 -5490 7010 -5460 {
lab=GND}
N 6890 -5520 6970 -5520 {
lab=VDD}
N 6860 -5670 6880 -5670 {
lab=o19}
N 6860 -5770 6860 -5670 {
lab=o19}
N 6860 -5770 6980 -5770 {
lab=o19}
N 6980 -5830 6980 -5770 {
lab=o19}
N 7070 -5660 7100 -5660 {
lab=ob19}
N 7070 -5750 7070 -5660 {
lab=ob19}
N 6820 -5750 6920 -5750 {
lab=ob19}
N 6820 -5970 6820 -5750 {
lab=ob19}
N 6820 -5970 6860 -5970 {
lab=ob19}
N 7140 -5970 7250 -5970 {
lab=o19}
N 7250 -5970 7250 -5740 {
lab=o19}
N 7140 -5740 7250 -5740 {
lab=o19}
N 6700 -5750 6820 -5750 {
lab=ob19}
N 7250 -5740 7340 -5740 {
lab=o19}
N 6670 -5840 6670 -5790 {
lab=rd}
N 7370 -5820 7370 -5780 {
lab=rd}
N 7400 -5740 7470 -5740 {
lab=b19}
N 6580 -5750 6640 -5750 {
lab=blb19}
N 7290 -5810 7290 -5740 {
lab=o19}
N 6760 -5840 6760 -5750 {
lab=ob19}
N 6590 -6280 6590 -5750 {
lab=blb19}
N 6590 -6280 6600 -6280 {
lab=blb19}
N 7450 -6220 7450 -5740 {
lab=b19}
N 6610 -6220 7450 -6220 {
lab=b19}
N 6610 -6420 6610 -6220 {
lab=b19}
N 6430 -6450 6430 -6440 {
lab=blb19}
N 6390 -6450 6390 -6420 {
lab=b19}
N 6190 -6110 6190 -6070 {
lab=#net138}
N 6190 -5840 6190 -5800 {
lab=#net139}
N 5990 -6140 6150 -6140 {
lab=#net140}
N 5990 -6140 5990 -5990 {
lab=#net140}
N 5990 -5990 5990 -5550 {
lab=#net140}
N 5990 -5550 6150 -5550 {
lab=#net140}
N 8250 -6430 8270 -6430 {
lab=blb20}
N 8250 -6410 8280 -6410 {
lab=b20}
N 9020 -6520 9020 -6430 {
lab=q20}
N 9180 -6520 9180 -6430 {
lab=qb20}
N 9060 -6550 9060 -6400 {
lab=qb20}
N 9140 -6550 9140 -6400 {
lab=q20}
N 9020 -6610 9020 -6580 {
lab=VDD}
N 9020 -6610 9180 -6610 {
lab=VDD}
N 9180 -6610 9180 -6580 {
lab=VDD}
N 9020 -6370 9020 -6330 {
lab=GND}
N 9020 -6330 9180 -6330 {
lab=GND}
N 9180 -6370 9180 -6330 {
lab=GND}
N 9100 -6330 9100 -6310 {
lab=GND}
N 9100 -6630 9100 -6610 {
lab=VDD}
N 8870 -6450 9020 -6450 {
lab=q20}
N 9180 -6460 9300 -6460 {
lab=qb20}
N 9060 -6460 9180 -6460 {
lab=qb20}
N 8760 -6450 8810 -6450 {
lab=b20}
N 9360 -6460 9400 -6460 {
lab=blb20}
N 8840 -6670 8840 -6490 {
lab=WL}
N 8840 -6670 9330 -6670 {
lab=WL}
N 9330 -6670 9330 -6500 {
lab=WL}
N 8760 -6670 8840 -6670 {
lab=WL}
N 9020 -6450 9140 -6450 {
lab=q20}
N 9260 -6500 9260 -6460 {
lab=qb20}
N 8930 -6490 8930 -6450 {
lab=q20}
N 8280 -6410 8760 -6410 {
lab=b20}
N 8760 -6450 8760 -6410 {
lab=b20}
N 8270 -6430 8750 -6430 {
lab=blb20}
N 8750 -6430 8750 -6270 {
lab=blb20}
N 8750 -6270 9410 -6270 {
lab=blb20}
N 9410 -6460 9410 -6270 {
lab=blb20}
N 9400 -6460 9410 -6460 {
lab=blb20}
N 8340 -6000 8340 -5890 {
lab=blb20}
N 8260 -6030 8300 -6030 {
lab=d20}
N 8260 -6030 8260 -5860 {
lab=d20}
N 8260 -5860 8300 -5860 {
lab=d20}
N 8340 -5510 8340 -5470 {
lab=#net141}
N 8340 -5410 8340 -5300 {
lab=b20}
N 8340 -5240 8340 -5200 {
lab=#net142}
N 8260 -5440 8300 -5440 {
lab=#net143}
N 8260 -5440 8260 -5270 {
lab=#net143}
N 8260 -5270 8300 -5270 {
lab=#net143}
N 8090 -5170 8300 -5170 {
lab=we}
N 8020 -5170 8090 -5170 {
lab=we}
N 8020 -5970 8020 -5170 {
lab=we}
N 8020 -5980 8020 -5970 {
lab=we}
N 8020 -5980 8080 -5980 {
lab=we}
N 8020 -5760 8300 -5760 {
lab=we}
N 8030 -5950 8030 -5870 {
lab=d20}
N 8030 -5950 8260 -5950 {
lab=d20}
N 8030 -5880 8030 -5350 {
lab=d20}
N 8030 -5350 8060 -5350 {
lab=d20}
N 8120 -5350 8260 -5350 {
lab=#net143}
N 8340 -5140 8340 -5100 {
lab=GND}
N 8340 -5730 8340 -5690 {
lab=GND}
N 8340 -6200 8340 -6160 {
lab=VDD}
N 8340 -5590 8340 -5570 {
lab=VDD}
N 8340 -5950 8500 -5950 {
lab=blb20}
N 8340 -5360 8490 -5360 {
lab=b20}
N 8490 -5360 8500 -5360 {
lab=b20}
N 7940 -5980 8020 -5980 {
lab=we}
N 7940 -5350 8030 -5350 {
lab=d20}
N 8470 -6430 8470 -5950 {
lab=blb20}
N 8480 -6410 8480 -5360 {
lab=b20}
N 7930 -6560 7930 -6470 {
lab=b20}
N 7840 -6560 7930 -6560 {
lab=b20}
N 7930 -6410 7930 -6340 {
lab=blb20}
N 7840 -6340 7930 -6340 {
lab=blb20}
N 7740 -6340 7780 -6340 {
lab=VDD}
N 7740 -6560 7740 -6340 {
lab=VDD}
N 7740 -6560 7780 -6560 {
lab=VDD}
N 7890 -6440 7890 -6270 {
lab=p_b}
N 7740 -6340 7740 -6260 {
lab=VDD}
N 7930 -6560 8000 -6560 {
lab=b20}
N 7810 -6520 7810 -6380 {
lab=p_b}
N 7810 -6410 7890 -6410 {
lab=p_b}
N 8150 -6430 8250 -6430 {
lab=blb20}
N 8150 -6430 8150 -6350 {
lab=blb20}
N 7930 -6350 8150 -6350 {
lab=blb20}
N 8000 -6410 8250 -6410 {
lab=b20}
N 8000 -6560 8000 -6410 {
lab=b20}
N 9200 -5960 9290 -5960 {
lab=o20}
N 9290 -6050 9290 -5960 {
lab=o20}
N 9070 -5960 9140 -5960 {
lab=ob20}
N 9070 -6050 9070 -5960 {
lab=ob20}
N 9070 -6150 9070 -6110 {
lab=VDD}
N 9070 -6150 9290 -6150 {
lab=VDD}
N 9290 -6150 9290 -6110 {
lab=VDD}
N 9000 -6000 9170 -6000 {
lab=p_b}
N 8990 -6150 9070 -6150 {
lab=VDD}
N 9000 -5960 9070 -5960 {
lab=ob20}
N 9110 -6080 9250 -6080 {
lab=p_b}
N 9140 -6080 9140 -6000 {
lab=p_b}
N 9290 -5860 9290 -5840 {
lab=VDD}
N 9070 -5860 9290 -5860 {
lab=VDD}
N 9070 -5860 9070 -5850 {
lab=VDD}
N 9110 -5820 9210 -5820 {
lab=o20}
N 9210 -5820 9210 -5760 {
lab=o20}
N 9210 -5760 9290 -5760 {
lab=o20}
N 9290 -5780 9290 -5760 {
lab=o20}
N 9330 -5810 9360 -5810 {
lab=ob20}
N 9360 -5810 9360 -5740 {
lab=ob20}
N 9070 -5740 9360 -5740 {
lab=ob20}
N 9070 -5790 9070 -5740 {
lab=ob20}
N 9290 -5760 9290 -5680 {
lab=o20}
N 9070 -5740 9070 -5690 {
lab=ob20}
N 9070 -5630 9070 -5600 {
lab=#net144}
N 9070 -5600 9290 -5600 {
lab=#net144}
N 9290 -5620 9290 -5600 {
lab=#net144}
N 9160 -5600 9160 -5540 {
lab=#net144}
N 9160 -5480 9160 -5450 {
lab=GND}
N 9040 -5510 9120 -5510 {
lab=VDD}
N 9010 -5660 9030 -5660 {
lab=o20}
N 9010 -5760 9010 -5660 {
lab=o20}
N 9010 -5760 9130 -5760 {
lab=o20}
N 9130 -5820 9130 -5760 {
lab=o20}
N 9220 -5650 9250 -5650 {
lab=ob20}
N 9220 -5740 9220 -5650 {
lab=ob20}
N 8970 -5740 9070 -5740 {
lab=ob20}
N 8970 -5960 8970 -5740 {
lab=ob20}
N 8970 -5960 9010 -5960 {
lab=ob20}
N 9290 -5960 9400 -5960 {
lab=o20}
N 9400 -5960 9400 -5730 {
lab=o20}
N 9290 -5730 9400 -5730 {
lab=o20}
N 8850 -5740 8970 -5740 {
lab=ob20}
N 9400 -5730 9490 -5730 {
lab=o20}
N 8820 -5830 8820 -5780 {
lab=rd}
N 9520 -5810 9520 -5770 {
lab=rd}
N 9550 -5730 9620 -5730 {
lab=b20}
N 8730 -5740 8790 -5740 {
lab=blb20}
N 9440 -5800 9440 -5730 {
lab=o20}
N 8910 -5830 8910 -5740 {
lab=ob20}
N 8740 -6270 8740 -5740 {
lab=blb20}
N 8740 -6270 8750 -6270 {
lab=blb20}
N 9600 -6210 9600 -5730 {
lab=b20}
N 8760 -6210 9600 -6210 {
lab=b20}
N 8760 -6410 8760 -6210 {
lab=b20}
N 8580 -6440 8580 -6430 {
lab=blb20}
N 8540 -6440 8540 -6410 {
lab=b20}
N 8340 -6100 8340 -6060 {
lab=#net145}
N 8340 -5830 8340 -5790 {
lab=#net146}
N 8140 -6130 8300 -6130 {
lab=#net147}
N 8140 -6130 8140 -5980 {
lab=#net147}
N 8140 -5980 8140 -5540 {
lab=#net147}
N 8140 -5540 8300 -5540 {
lab=#net147}
N 10380 -6430 10400 -6430 {
lab=blb21}
N 10380 -6410 10410 -6410 {
lab=b21}
N 11150 -6520 11150 -6430 {
lab=q21}
N 11310 -6520 11310 -6430 {
lab=qb21}
N 11190 -6550 11190 -6400 {
lab=qb21}
N 11270 -6550 11270 -6400 {
lab=q21}
N 11150 -6610 11150 -6580 {
lab=VDD}
N 11150 -6610 11310 -6610 {
lab=VDD}
N 11310 -6610 11310 -6580 {
lab=VDD}
N 11150 -6370 11150 -6330 {
lab=GND}
N 11150 -6330 11310 -6330 {
lab=GND}
N 11310 -6370 11310 -6330 {
lab=GND}
N 11230 -6330 11230 -6310 {
lab=GND}
N 11230 -6630 11230 -6610 {
lab=VDD}
N 11000 -6450 11150 -6450 {
lab=q21}
N 11310 -6460 11430 -6460 {
lab=qb21}
N 11190 -6460 11310 -6460 {
lab=qb21}
N 10890 -6450 10940 -6450 {
lab=b21}
N 11490 -6460 11530 -6460 {
lab=blb21}
N 10970 -6670 10970 -6490 {
lab=WL}
N 10970 -6670 11460 -6670 {
lab=WL}
N 11460 -6670 11460 -6500 {
lab=WL}
N 10890 -6670 10970 -6670 {
lab=WL}
N 11150 -6450 11270 -6450 {
lab=q21}
N 11390 -6500 11390 -6460 {
lab=qb21}
N 11060 -6490 11060 -6450 {
lab=q21}
N 10410 -6410 10890 -6410 {
lab=b21}
N 10890 -6450 10890 -6410 {
lab=b21}
N 10400 -6430 10880 -6430 {
lab=blb21}
N 10880 -6430 10880 -6270 {
lab=blb21}
N 10880 -6270 11540 -6270 {
lab=blb21}
N 11540 -6460 11540 -6270 {
lab=blb21}
N 11530 -6460 11540 -6460 {
lab=blb21}
N 10470 -6000 10470 -5890 {
lab=blb21}
N 10390 -6030 10430 -6030 {
lab=d21}
N 10390 -6030 10390 -5860 {
lab=d21}
N 10390 -5860 10430 -5860 {
lab=d21}
N 10470 -5510 10470 -5470 {
lab=#net148}
N 10470 -5410 10470 -5300 {
lab=b21}
N 10470 -5240 10470 -5200 {
lab=#net149}
N 10390 -5440 10430 -5440 {
lab=#net150}
N 10390 -5440 10390 -5270 {
lab=#net150}
N 10390 -5270 10430 -5270 {
lab=#net150}
N 10220 -5170 10430 -5170 {
lab=we}
N 10150 -5170 10220 -5170 {
lab=we}
N 10150 -5970 10150 -5170 {
lab=we}
N 10150 -5980 10150 -5970 {
lab=we}
N 10150 -5980 10210 -5980 {
lab=we}
N 10150 -5760 10430 -5760 {
lab=we}
N 10160 -5950 10160 -5870 {
lab=d21}
N 10160 -5950 10390 -5950 {
lab=d21}
N 10160 -5880 10160 -5350 {
lab=d21}
N 10160 -5350 10190 -5350 {
lab=d21}
N 10250 -5350 10390 -5350 {
lab=#net150}
N 10470 -5140 10470 -5100 {
lab=GND}
N 10470 -5730 10470 -5690 {
lab=GND}
N 10470 -6200 10470 -6160 {
lab=VDD}
N 10470 -5590 10470 -5570 {
lab=VDD}
N 10470 -5950 10630 -5950 {
lab=blb21}
N 10470 -5360 10620 -5360 {
lab=b21}
N 10620 -5360 10630 -5360 {
lab=b21}
N 10070 -5980 10150 -5980 {
lab=we}
N 10070 -5350 10160 -5350 {
lab=d21}
N 10600 -6430 10600 -5950 {
lab=blb21}
N 10610 -6410 10610 -5360 {
lab=b21}
N 10060 -6560 10060 -6470 {
lab=b21}
N 9970 -6560 10060 -6560 {
lab=b21}
N 10060 -6410 10060 -6340 {
lab=blb21}
N 9970 -6340 10060 -6340 {
lab=blb21}
N 9870 -6340 9910 -6340 {
lab=VDD}
N 9870 -6560 9870 -6340 {
lab=VDD}
N 9870 -6560 9910 -6560 {
lab=VDD}
N 10020 -6440 10020 -6270 {
lab=p_b}
N 9870 -6340 9870 -6260 {
lab=VDD}
N 10060 -6560 10130 -6560 {
lab=b21}
N 9940 -6520 9940 -6380 {
lab=p_b}
N 9940 -6410 10020 -6410 {
lab=p_b}
N 10280 -6430 10380 -6430 {
lab=blb21}
N 10280 -6430 10280 -6350 {
lab=blb21}
N 10060 -6350 10280 -6350 {
lab=blb21}
N 10130 -6410 10380 -6410 {
lab=b21}
N 10130 -6560 10130 -6410 {
lab=b21}
N 11330 -5960 11420 -5960 {
lab=o21}
N 11420 -6050 11420 -5960 {
lab=o21}
N 11200 -5960 11270 -5960 {
lab=ob21}
N 11200 -6050 11200 -5960 {
lab=ob21}
N 11200 -6150 11200 -6110 {
lab=VDD}
N 11200 -6150 11420 -6150 {
lab=VDD}
N 11420 -6150 11420 -6110 {
lab=VDD}
N 11130 -6000 11300 -6000 {
lab=p_b}
N 11120 -6150 11200 -6150 {
lab=VDD}
N 11130 -5960 11200 -5960 {
lab=ob21}
N 11240 -6080 11380 -6080 {
lab=p_b}
N 11270 -6080 11270 -6000 {
lab=p_b}
N 11420 -5860 11420 -5840 {
lab=VDD}
N 11200 -5860 11420 -5860 {
lab=VDD}
N 11200 -5860 11200 -5850 {
lab=VDD}
N 11240 -5820 11340 -5820 {
lab=o21}
N 11340 -5820 11340 -5760 {
lab=o21}
N 11340 -5760 11420 -5760 {
lab=o21}
N 11420 -5780 11420 -5760 {
lab=o21}
N 11460 -5810 11490 -5810 {
lab=ob21}
N 11490 -5810 11490 -5740 {
lab=ob21}
N 11200 -5740 11490 -5740 {
lab=ob21}
N 11200 -5790 11200 -5740 {
lab=ob21}
N 11420 -5760 11420 -5680 {
lab=o21}
N 11200 -5740 11200 -5690 {
lab=ob21}
N 11200 -5630 11200 -5600 {
lab=#net151}
N 11200 -5600 11420 -5600 {
lab=#net151}
N 11420 -5620 11420 -5600 {
lab=#net151}
N 11290 -5600 11290 -5540 {
lab=#net151}
N 11290 -5480 11290 -5450 {
lab=GND}
N 11170 -5510 11250 -5510 {
lab=VDD}
N 11140 -5660 11160 -5660 {
lab=o21}
N 11140 -5760 11140 -5660 {
lab=o21}
N 11140 -5760 11260 -5760 {
lab=o21}
N 11260 -5820 11260 -5760 {
lab=o21}
N 11350 -5650 11380 -5650 {
lab=ob21}
N 11350 -5740 11350 -5650 {
lab=ob21}
N 11100 -5740 11200 -5740 {
lab=ob21}
N 11100 -5960 11100 -5740 {
lab=ob21}
N 11100 -5960 11140 -5960 {
lab=ob21}
N 11420 -5960 11530 -5960 {
lab=o21}
N 11530 -5960 11530 -5730 {
lab=o21}
N 11420 -5730 11530 -5730 {
lab=o21}
N 10980 -5740 11100 -5740 {
lab=ob21}
N 11530 -5730 11620 -5730 {
lab=o21}
N 10950 -5830 10950 -5780 {
lab=rd}
N 11650 -5810 11650 -5770 {
lab=rd}
N 11680 -5730 11750 -5730 {
lab=b21}
N 10860 -5740 10920 -5740 {
lab=blb21}
N 11570 -5800 11570 -5730 {
lab=o21}
N 11040 -5830 11040 -5740 {
lab=ob21}
N 10870 -6270 10870 -5740 {
lab=blb21}
N 10870 -6270 10880 -6270 {
lab=blb21}
N 11730 -6210 11730 -5730 {
lab=b21}
N 10890 -6210 11730 -6210 {
lab=b21}
N 10890 -6410 10890 -6210 {
lab=b21}
N 10710 -6440 10710 -6430 {
lab=blb21}
N 10670 -6440 10670 -6410 {
lab=b21}
N 10470 -6100 10470 -6060 {
lab=#net152}
N 10470 -5830 10470 -5790 {
lab=#net153}
N 10270 -6130 10430 -6130 {
lab=#net154}
N 10270 -6130 10270 -5980 {
lab=#net154}
N 10270 -5980 10270 -5540 {
lab=#net154}
N 10270 -5540 10430 -5540 {
lab=#net154}
N 12700 -6410 12720 -6410 {
lab=blb22}
N 12700 -6390 12730 -6390 {
lab=b22}
N 13470 -6500 13470 -6410 {
lab=q22}
N 13630 -6500 13630 -6410 {
lab=qb22}
N 13510 -6530 13510 -6380 {
lab=qb22}
N 13590 -6530 13590 -6380 {
lab=q22}
N 13470 -6590 13470 -6560 {
lab=VDD}
N 13470 -6590 13630 -6590 {
lab=VDD}
N 13630 -6590 13630 -6560 {
lab=VDD}
N 13470 -6350 13470 -6310 {
lab=GND}
N 13470 -6310 13630 -6310 {
lab=GND}
N 13630 -6350 13630 -6310 {
lab=GND}
N 13550 -6310 13550 -6290 {
lab=GND}
N 13550 -6610 13550 -6590 {
lab=VDD}
N 13320 -6430 13470 -6430 {
lab=q22}
N 13630 -6440 13750 -6440 {
lab=qb22}
N 13510 -6440 13630 -6440 {
lab=qb22}
N 13210 -6430 13260 -6430 {
lab=b22}
N 13810 -6440 13850 -6440 {
lab=blb22}
N 13290 -6650 13290 -6470 {
lab=WL}
N 13290 -6650 13780 -6650 {
lab=WL}
N 13780 -6650 13780 -6480 {
lab=WL}
N 13210 -6650 13290 -6650 {
lab=WL}
N 13470 -6430 13590 -6430 {
lab=q22}
N 13710 -6480 13710 -6440 {
lab=qb22}
N 13380 -6470 13380 -6430 {
lab=q22}
N 12730 -6390 13210 -6390 {
lab=b22}
N 13210 -6430 13210 -6390 {
lab=b22}
N 12720 -6410 13200 -6410 {
lab=blb22}
N 13200 -6410 13200 -6250 {
lab=blb22}
N 13200 -6250 13860 -6250 {
lab=blb22}
N 13860 -6440 13860 -6250 {
lab=blb22}
N 13850 -6440 13860 -6440 {
lab=blb22}
N 12790 -5980 12790 -5870 {
lab=blb22}
N 12710 -6010 12750 -6010 {
lab=d22}
N 12710 -6010 12710 -5840 {
lab=d22}
N 12710 -5840 12750 -5840 {
lab=d22}
N 12790 -5490 12790 -5450 {
lab=#net155}
N 12790 -5390 12790 -5280 {
lab=b22}
N 12790 -5220 12790 -5180 {
lab=#net156}
N 12710 -5420 12750 -5420 {
lab=#net157}
N 12710 -5420 12710 -5250 {
lab=#net157}
N 12710 -5250 12750 -5250 {
lab=#net157}
N 12540 -5150 12750 -5150 {
lab=we}
N 12470 -5150 12540 -5150 {
lab=we}
N 12470 -5950 12470 -5150 {
lab=we}
N 12470 -5960 12470 -5950 {
lab=we}
N 12470 -5960 12530 -5960 {
lab=we}
N 12470 -5740 12750 -5740 {
lab=we}
N 12480 -5930 12480 -5850 {
lab=d22}
N 12480 -5930 12710 -5930 {
lab=d22}
N 12480 -5860 12480 -5330 {
lab=d22}
N 12480 -5330 12510 -5330 {
lab=d22}
N 12570 -5330 12710 -5330 {
lab=#net157}
N 12790 -5120 12790 -5080 {
lab=GND}
N 12790 -5710 12790 -5670 {
lab=GND}
N 12790 -6180 12790 -6140 {
lab=VDD}
N 12790 -5570 12790 -5550 {
lab=VDD}
N 12790 -5930 12950 -5930 {
lab=blb22}
N 12790 -5340 12940 -5340 {
lab=b22}
N 12940 -5340 12950 -5340 {
lab=b22}
N 12390 -5960 12470 -5960 {
lab=we}
N 12390 -5330 12480 -5330 {
lab=d22}
N 12920 -6410 12920 -5930 {
lab=blb22}
N 12930 -6390 12930 -5340 {
lab=b22}
N 12380 -6540 12380 -6450 {
lab=b22}
N 12290 -6540 12380 -6540 {
lab=b22}
N 12380 -6390 12380 -6320 {
lab=blb22}
N 12290 -6320 12380 -6320 {
lab=blb22}
N 12190 -6320 12230 -6320 {
lab=VDD}
N 12190 -6540 12190 -6320 {
lab=VDD}
N 12190 -6540 12230 -6540 {
lab=VDD}
N 12340 -6420 12340 -6250 {
lab=p_b}
N 12190 -6320 12190 -6240 {
lab=VDD}
N 12380 -6540 12450 -6540 {
lab=b22}
N 12260 -6500 12260 -6360 {
lab=p_b}
N 12260 -6390 12340 -6390 {
lab=p_b}
N 12600 -6410 12700 -6410 {
lab=blb22}
N 12600 -6410 12600 -6330 {
lab=blb22}
N 12380 -6330 12600 -6330 {
lab=blb22}
N 12450 -6390 12700 -6390 {
lab=b22}
N 12450 -6540 12450 -6390 {
lab=b22}
N 13650 -5940 13740 -5940 {
lab=o22}
N 13740 -6030 13740 -5940 {
lab=o22}
N 13520 -5940 13590 -5940 {
lab=ob22}
N 13520 -6030 13520 -5940 {
lab=ob22}
N 13520 -6130 13520 -6090 {
lab=VDD}
N 13520 -6130 13740 -6130 {
lab=VDD}
N 13740 -6130 13740 -6090 {
lab=VDD}
N 13450 -5980 13620 -5980 {
lab=p_b}
N 13440 -6130 13520 -6130 {
lab=VDD}
N 13450 -5940 13520 -5940 {
lab=ob22}
N 13560 -6060 13700 -6060 {
lab=p_b}
N 13590 -6060 13590 -5980 {
lab=p_b}
N 13740 -5840 13740 -5820 {
lab=VDD}
N 13520 -5840 13740 -5840 {
lab=VDD}
N 13520 -5840 13520 -5830 {
lab=VDD}
N 13560 -5800 13660 -5800 {
lab=o22}
N 13660 -5800 13660 -5740 {
lab=o22}
N 13660 -5740 13740 -5740 {
lab=o22}
N 13740 -5760 13740 -5740 {
lab=o22}
N 13780 -5790 13810 -5790 {
lab=ob22}
N 13810 -5790 13810 -5720 {
lab=ob22}
N 13520 -5720 13810 -5720 {
lab=ob22}
N 13520 -5770 13520 -5720 {
lab=ob22}
N 13740 -5740 13740 -5660 {
lab=o22}
N 13520 -5720 13520 -5670 {
lab=ob22}
N 13520 -5610 13520 -5580 {
lab=#net158}
N 13520 -5580 13740 -5580 {
lab=#net158}
N 13740 -5600 13740 -5580 {
lab=#net158}
N 13610 -5580 13610 -5520 {
lab=#net158}
N 13610 -5460 13610 -5430 {
lab=GND}
N 13490 -5490 13570 -5490 {
lab=VDD}
N 13460 -5640 13480 -5640 {
lab=o22}
N 13460 -5740 13460 -5640 {
lab=o22}
N 13460 -5740 13580 -5740 {
lab=o22}
N 13580 -5800 13580 -5740 {
lab=o22}
N 13670 -5630 13700 -5630 {
lab=ob22}
N 13670 -5720 13670 -5630 {
lab=ob22}
N 13420 -5720 13520 -5720 {
lab=ob22}
N 13420 -5940 13420 -5720 {
lab=ob22}
N 13420 -5940 13460 -5940 {
lab=ob22}
N 13740 -5940 13850 -5940 {
lab=o22}
N 13850 -5940 13850 -5710 {
lab=o22}
N 13740 -5710 13850 -5710 {
lab=o22}
N 13300 -5720 13420 -5720 {
lab=ob22}
N 13850 -5710 13940 -5710 {
lab=o22}
N 13270 -5810 13270 -5760 {
lab=rd}
N 13970 -5790 13970 -5750 {
lab=rd}
N 14000 -5710 14070 -5710 {
lab=b22}
N 13180 -5720 13240 -5720 {
lab=blb22}
N 13890 -5780 13890 -5710 {
lab=o22}
N 13360 -5810 13360 -5720 {
lab=ob22}
N 13190 -6250 13190 -5720 {
lab=blb22}
N 13190 -6250 13200 -6250 {
lab=blb22}
N 14050 -6190 14050 -5710 {
lab=b22}
N 13210 -6190 14050 -6190 {
lab=b22}
N 13210 -6390 13210 -6190 {
lab=b22}
N 13030 -6420 13030 -6410 {
lab=blb22}
N 12990 -6420 12990 -6390 {
lab=b22}
N 12790 -6080 12790 -6040 {
lab=#net159}
N 12790 -5810 12790 -5770 {
lab=#net160}
N 12590 -6110 12750 -6110 {
lab=#net161}
N 12590 -6110 12590 -5960 {
lab=#net161}
N 12590 -5960 12590 -5520 {
lab=#net161}
N 12590 -5520 12750 -5520 {
lab=#net161}
N 14850 -6400 14870 -6400 {
lab=blb23}
N 14850 -6380 14880 -6380 {
lab=b23}
N 15620 -6490 15620 -6400 {
lab=q23}
N 15780 -6490 15780 -6400 {
lab=qb23}
N 15660 -6520 15660 -6370 {
lab=qb23}
N 15740 -6520 15740 -6370 {
lab=q23}
N 15620 -6580 15620 -6550 {
lab=VDD}
N 15620 -6580 15780 -6580 {
lab=VDD}
N 15780 -6580 15780 -6550 {
lab=VDD}
N 15620 -6340 15620 -6300 {
lab=GND}
N 15620 -6300 15780 -6300 {
lab=GND}
N 15780 -6340 15780 -6300 {
lab=GND}
N 15700 -6300 15700 -6280 {
lab=GND}
N 15700 -6600 15700 -6580 {
lab=VDD}
N 15470 -6420 15620 -6420 {
lab=q23}
N 15780 -6430 15900 -6430 {
lab=qb23}
N 15660 -6430 15780 -6430 {
lab=qb23}
N 15360 -6420 15410 -6420 {
lab=b23}
N 15960 -6430 16000 -6430 {
lab=blb23}
N 15440 -6640 15440 -6460 {
lab=WL}
N 15440 -6640 15930 -6640 {
lab=WL}
N 15930 -6640 15930 -6470 {
lab=WL}
N 15360 -6640 15440 -6640 {
lab=WL}
N 15620 -6420 15740 -6420 {
lab=q23}
N 15860 -6470 15860 -6430 {
lab=qb23}
N 15530 -6460 15530 -6420 {
lab=q23}
N 14880 -6380 15360 -6380 {
lab=b23}
N 15360 -6420 15360 -6380 {
lab=b23}
N 14870 -6400 15350 -6400 {
lab=blb23}
N 15350 -6400 15350 -6240 {
lab=blb23}
N 15350 -6240 16010 -6240 {
lab=blb23}
N 16010 -6430 16010 -6240 {
lab=blb23}
N 16000 -6430 16010 -6430 {
lab=blb23}
N 14940 -5970 14940 -5860 {
lab=blb23}
N 14860 -6000 14900 -6000 {
lab=d23}
N 14860 -6000 14860 -5830 {
lab=d23}
N 14860 -5830 14900 -5830 {
lab=d23}
N 14940 -5480 14940 -5440 {
lab=#net162}
N 14940 -5380 14940 -5270 {
lab=b23}
N 14940 -5210 14940 -5170 {
lab=#net163}
N 14860 -5410 14900 -5410 {
lab=#net164}
N 14860 -5410 14860 -5240 {
lab=#net164}
N 14860 -5240 14900 -5240 {
lab=#net164}
N 14690 -5140 14900 -5140 {
lab=we}
N 14620 -5140 14690 -5140 {
lab=we}
N 14620 -5940 14620 -5140 {
lab=we}
N 14620 -5950 14620 -5940 {
lab=we}
N 14620 -5950 14680 -5950 {
lab=we}
N 14620 -5730 14900 -5730 {
lab=we}
N 14630 -5920 14630 -5840 {
lab=d23}
N 14630 -5920 14860 -5920 {
lab=d23}
N 14630 -5850 14630 -5320 {
lab=d23}
N 14630 -5320 14660 -5320 {
lab=d23}
N 14720 -5320 14860 -5320 {
lab=#net164}
N 14940 -5110 14940 -5070 {
lab=GND}
N 14940 -5700 14940 -5660 {
lab=GND}
N 14940 -6170 14940 -6130 {
lab=VDD}
N 14940 -5560 14940 -5540 {
lab=VDD}
N 14940 -5920 15100 -5920 {
lab=blb23}
N 14940 -5330 15090 -5330 {
lab=b23}
N 15090 -5330 15100 -5330 {
lab=b23}
N 14540 -5950 14620 -5950 {
lab=we}
N 14540 -5320 14630 -5320 {
lab=d23}
N 15070 -6400 15070 -5920 {
lab=blb23}
N 15080 -6380 15080 -5330 {
lab=b23}
N 14530 -6530 14530 -6440 {
lab=b23}
N 14440 -6530 14530 -6530 {
lab=b23}
N 14530 -6380 14530 -6310 {
lab=blb23}
N 14440 -6310 14530 -6310 {
lab=blb23}
N 14340 -6310 14380 -6310 {
lab=VDD}
N 14340 -6530 14340 -6310 {
lab=VDD}
N 14340 -6530 14380 -6530 {
lab=VDD}
N 14490 -6410 14490 -6240 {
lab=p_b}
N 14340 -6310 14340 -6230 {
lab=VDD}
N 14530 -6530 14600 -6530 {
lab=b23}
N 14410 -6490 14410 -6350 {
lab=p_b}
N 14410 -6380 14490 -6380 {
lab=p_b}
N 14750 -6400 14850 -6400 {
lab=blb23}
N 14750 -6400 14750 -6320 {
lab=blb23}
N 14530 -6320 14750 -6320 {
lab=blb23}
N 14600 -6380 14850 -6380 {
lab=b23}
N 14600 -6530 14600 -6380 {
lab=b23}
N 15800 -5930 15890 -5930 {
lab=o23}
N 15890 -6020 15890 -5930 {
lab=o23}
N 15670 -5930 15740 -5930 {
lab=ob23}
N 15670 -6020 15670 -5930 {
lab=ob23}
N 15670 -6120 15670 -6080 {
lab=VDD}
N 15670 -6120 15890 -6120 {
lab=VDD}
N 15890 -6120 15890 -6080 {
lab=VDD}
N 15600 -5970 15770 -5970 {
lab=p_b}
N 15590 -6120 15670 -6120 {
lab=VDD}
N 15600 -5930 15670 -5930 {
lab=ob23}
N 15710 -6050 15850 -6050 {
lab=p_b}
N 15740 -6050 15740 -5970 {
lab=p_b}
N 15890 -5830 15890 -5810 {
lab=VDD}
N 15670 -5830 15890 -5830 {
lab=VDD}
N 15670 -5830 15670 -5820 {
lab=VDD}
N 15710 -5790 15810 -5790 {
lab=o23}
N 15810 -5790 15810 -5730 {
lab=o23}
N 15810 -5730 15890 -5730 {
lab=o23}
N 15890 -5750 15890 -5730 {
lab=o23}
N 15930 -5780 15960 -5780 {
lab=ob23}
N 15960 -5780 15960 -5710 {
lab=ob23}
N 15670 -5710 15960 -5710 {
lab=ob23}
N 15670 -5760 15670 -5710 {
lab=ob23}
N 15890 -5730 15890 -5650 {
lab=o23}
N 15670 -5710 15670 -5660 {
lab=ob23}
N 15670 -5600 15670 -5570 {
lab=#net165}
N 15670 -5570 15890 -5570 {
lab=#net165}
N 15890 -5590 15890 -5570 {
lab=#net165}
N 15760 -5570 15760 -5510 {
lab=#net165}
N 15760 -5450 15760 -5420 {
lab=GND}
N 15640 -5480 15720 -5480 {
lab=VDD}
N 15610 -5630 15630 -5630 {
lab=o23}
N 15610 -5730 15610 -5630 {
lab=o23}
N 15610 -5730 15730 -5730 {
lab=o23}
N 15730 -5790 15730 -5730 {
lab=o23}
N 15820 -5620 15850 -5620 {
lab=ob23}
N 15820 -5710 15820 -5620 {
lab=ob23}
N 15570 -5710 15670 -5710 {
lab=ob23}
N 15570 -5930 15570 -5710 {
lab=ob23}
N 15570 -5930 15610 -5930 {
lab=ob23}
N 15890 -5930 16000 -5930 {
lab=o23}
N 16000 -5930 16000 -5700 {
lab=o23}
N 15890 -5700 16000 -5700 {
lab=o23}
N 15450 -5710 15570 -5710 {
lab=ob23}
N 16000 -5700 16090 -5700 {
lab=o23}
N 15420 -5800 15420 -5750 {
lab=rd}
N 16120 -5780 16120 -5740 {
lab=rd}
N 16150 -5700 16220 -5700 {
lab=b23}
N 15330 -5710 15390 -5710 {
lab=blb23}
N 16040 -5770 16040 -5700 {
lab=o23}
N 15510 -5800 15510 -5710 {
lab=ob23}
N 15340 -6240 15340 -5710 {
lab=blb23}
N 15340 -6240 15350 -6240 {
lab=blb23}
N 16200 -6180 16200 -5700 {
lab=b23}
N 15360 -6180 16200 -6180 {
lab=b23}
N 15360 -6380 15360 -6180 {
lab=b23}
N 15180 -6410 15180 -6400 {
lab=blb23}
N 15140 -6410 15140 -6380 {
lab=b23}
N 14940 -6070 14940 -6030 {
lab=#net166}
N 14940 -5800 14940 -5760 {
lab=#net167}
N 14740 -6100 14900 -6100 {
lab=#net168}
N 14740 -6100 14740 -5950 {
lab=#net168}
N 14740 -5950 14740 -5510 {
lab=#net168}
N 14740 -5510 14900 -5510 {
lab=#net168}
N 3980 -4100 4000 -4100 {
lab=blb24}
N 3980 -4080 4010 -4080 {
lab=b24}
N 4750 -4190 4750 -4100 {
lab=q24}
N 4910 -4190 4910 -4100 {
lab=qb24}
N 4790 -4220 4790 -4070 {
lab=qb24}
N 4870 -4220 4870 -4070 {
lab=q24}
N 4750 -4280 4750 -4250 {
lab=VDD}
N 4750 -4280 4910 -4280 {
lab=VDD}
N 4910 -4280 4910 -4250 {
lab=VDD}
N 4750 -4040 4750 -4000 {
lab=GND}
N 4750 -4000 4910 -4000 {
lab=GND}
N 4910 -4040 4910 -4000 {
lab=GND}
N 4830 -4000 4830 -3980 {
lab=GND}
N 4830 -4300 4830 -4280 {
lab=VDD}
N 4600 -4120 4750 -4120 {
lab=q24}
N 4910 -4130 5030 -4130 {
lab=qb24}
N 4790 -4130 4910 -4130 {
lab=qb24}
N 4490 -4120 4540 -4120 {
lab=b24}
N 5090 -4130 5130 -4130 {
lab=blb24}
N 4570 -4340 4570 -4160 {
lab=WL}
N 4570 -4340 5060 -4340 {
lab=WL}
N 5060 -4340 5060 -4170 {
lab=WL}
N 4490 -4340 4570 -4340 {
lab=WL}
N 4750 -4120 4870 -4120 {
lab=q24}
N 4990 -4170 4990 -4130 {
lab=qb24}
N 4660 -4160 4660 -4120 {
lab=q24}
N 4010 -4080 4490 -4080 {
lab=b24}
N 4490 -4120 4490 -4080 {
lab=b24}
N 4000 -4100 4480 -4100 {
lab=blb24}
N 4480 -4100 4480 -3940 {
lab=blb24}
N 4480 -3940 5140 -3940 {
lab=blb24}
N 5140 -4130 5140 -3940 {
lab=blb24}
N 5130 -4130 5140 -4130 {
lab=blb24}
N 4070 -3670 4070 -3560 {
lab=blb24}
N 3990 -3700 4030 -3700 {
lab=d24}
N 3990 -3700 3990 -3530 {
lab=d24}
N 3990 -3530 4030 -3530 {
lab=d24}
N 4070 -3180 4070 -3140 {
lab=#net169}
N 4070 -3080 4070 -2970 {
lab=b24}
N 4070 -2910 4070 -2870 {
lab=#net170}
N 3990 -3110 4030 -3110 {
lab=#net171}
N 3990 -3110 3990 -2940 {
lab=#net171}
N 3990 -2940 4030 -2940 {
lab=#net171}
N 3820 -2840 4030 -2840 {
lab=we}
N 3750 -2840 3820 -2840 {
lab=we}
N 3750 -3640 3750 -2840 {
lab=we}
N 3750 -3650 3750 -3640 {
lab=we}
N 3750 -3650 3810 -3650 {
lab=we}
N 3750 -3430 4030 -3430 {
lab=we}
N 3760 -3620 3760 -3540 {
lab=d24}
N 3760 -3620 3990 -3620 {
lab=d24}
N 3760 -3550 3760 -3020 {
lab=d24}
N 3760 -3020 3790 -3020 {
lab=d24}
N 3850 -3020 3990 -3020 {
lab=#net171}
N 4070 -2810 4070 -2770 {
lab=GND}
N 4070 -3400 4070 -3360 {
lab=GND}
N 4070 -3870 4070 -3830 {
lab=VDD}
N 4070 -3260 4070 -3240 {
lab=VDD}
N 4070 -3620 4230 -3620 {
lab=blb24}
N 4070 -3030 4220 -3030 {
lab=b24}
N 4220 -3030 4230 -3030 {
lab=b24}
N 3670 -3650 3750 -3650 {
lab=we}
N 3670 -3020 3760 -3020 {
lab=d24}
N 4200 -4100 4200 -3620 {
lab=blb24}
N 4210 -4080 4210 -3030 {
lab=b24}
N 3660 -4230 3660 -4140 {
lab=b24}
N 3570 -4230 3660 -4230 {
lab=b24}
N 3660 -4080 3660 -4010 {
lab=blb24}
N 3570 -4010 3660 -4010 {
lab=blb24}
N 3470 -4010 3510 -4010 {
lab=VDD}
N 3470 -4230 3470 -4010 {
lab=VDD}
N 3470 -4230 3510 -4230 {
lab=VDD}
N 3620 -4110 3620 -3940 {
lab=p_b}
N 3470 -4010 3470 -3930 {
lab=VDD}
N 3660 -4230 3730 -4230 {
lab=b24}
N 3540 -4190 3540 -4050 {
lab=p_b}
N 3540 -4080 3620 -4080 {
lab=p_b}
N 3880 -4100 3980 -4100 {
lab=blb24}
N 3880 -4100 3880 -4020 {
lab=blb24}
N 3660 -4020 3880 -4020 {
lab=blb24}
N 3730 -4080 3980 -4080 {
lab=b24}
N 3730 -4230 3730 -4080 {
lab=b24}
N 4930 -3630 5020 -3630 {
lab=o24}
N 5020 -3720 5020 -3630 {
lab=o24}
N 4800 -3630 4870 -3630 {
lab=ob24}
N 4800 -3720 4800 -3630 {
lab=ob24}
N 4800 -3820 4800 -3780 {
lab=VDD}
N 4800 -3820 5020 -3820 {
lab=VDD}
N 5020 -3820 5020 -3780 {
lab=VDD}
N 4730 -3670 4900 -3670 {
lab=p_b}
N 4720 -3820 4800 -3820 {
lab=VDD}
N 4730 -3630 4800 -3630 {
lab=ob24}
N 4840 -3750 4980 -3750 {
lab=p_b}
N 4870 -3750 4870 -3670 {
lab=p_b}
N 5020 -3530 5020 -3510 {
lab=VDD}
N 4800 -3530 5020 -3530 {
lab=VDD}
N 4800 -3530 4800 -3520 {
lab=VDD}
N 4840 -3490 4940 -3490 {
lab=o24}
N 4940 -3490 4940 -3430 {
lab=o24}
N 4940 -3430 5020 -3430 {
lab=o24}
N 5020 -3450 5020 -3430 {
lab=o24}
N 5060 -3480 5090 -3480 {
lab=ob24}
N 5090 -3480 5090 -3410 {
lab=ob24}
N 4800 -3410 5090 -3410 {
lab=ob24}
N 4800 -3460 4800 -3410 {
lab=ob24}
N 5020 -3430 5020 -3350 {
lab=o24}
N 4800 -3410 4800 -3360 {
lab=ob24}
N 4800 -3300 4800 -3270 {
lab=#net172}
N 4800 -3270 5020 -3270 {
lab=#net172}
N 5020 -3290 5020 -3270 {
lab=#net172}
N 4890 -3270 4890 -3210 {
lab=#net172}
N 4890 -3150 4890 -3120 {
lab=GND}
N 4770 -3180 4850 -3180 {
lab=VDD}
N 4740 -3330 4760 -3330 {
lab=o24}
N 4740 -3430 4740 -3330 {
lab=o24}
N 4740 -3430 4860 -3430 {
lab=o24}
N 4860 -3490 4860 -3430 {
lab=o24}
N 4950 -3320 4980 -3320 {
lab=ob24}
N 4950 -3410 4950 -3320 {
lab=ob24}
N 4700 -3410 4800 -3410 {
lab=ob24}
N 4700 -3630 4700 -3410 {
lab=ob24}
N 4700 -3630 4740 -3630 {
lab=ob24}
N 5020 -3630 5130 -3630 {
lab=o24}
N 5130 -3630 5130 -3400 {
lab=o24}
N 5020 -3400 5130 -3400 {
lab=o24}
N 4580 -3410 4700 -3410 {
lab=ob24}
N 5130 -3400 5220 -3400 {
lab=o24}
N 4550 -3500 4550 -3450 {
lab=rd}
N 5250 -3480 5250 -3440 {
lab=rd}
N 5280 -3400 5350 -3400 {
lab=b24}
N 4460 -3410 4520 -3410 {
lab=blb24}
N 5170 -3470 5170 -3400 {
lab=o24}
N 4640 -3500 4640 -3410 {
lab=ob24}
N 4470 -3940 4470 -3410 {
lab=blb24}
N 4470 -3940 4480 -3940 {
lab=blb24}
N 5330 -3880 5330 -3400 {
lab=b24}
N 4490 -3880 5330 -3880 {
lab=b24}
N 4490 -4080 4490 -3880 {
lab=b24}
N 4310 -4110 4310 -4100 {
lab=blb24}
N 4270 -4110 4270 -4080 {
lab=b24}
N 4070 -3770 4070 -3730 {
lab=#net173}
N 4070 -3500 4070 -3460 {
lab=#net174}
N 3870 -3800 4030 -3800 {
lab=#net175}
N 3870 -3800 3870 -3650 {
lab=#net175}
N 3870 -3650 3870 -3210 {
lab=#net175}
N 3870 -3210 4030 -3210 {
lab=#net175}
N 6300 -4080 6320 -4080 {
lab=blb25}
N 6300 -4060 6330 -4060 {
lab=b25}
N 7070 -4170 7070 -4080 {
lab=q25}
N 7230 -4170 7230 -4080 {
lab=qb25}
N 7110 -4200 7110 -4050 {
lab=qb25}
N 7190 -4200 7190 -4050 {
lab=q25}
N 7070 -4260 7070 -4230 {
lab=VDD}
N 7070 -4260 7230 -4260 {
lab=VDD}
N 7230 -4260 7230 -4230 {
lab=VDD}
N 7070 -4020 7070 -3980 {
lab=GND}
N 7070 -3980 7230 -3980 {
lab=GND}
N 7230 -4020 7230 -3980 {
lab=GND}
N 7150 -3980 7150 -3960 {
lab=GND}
N 7150 -4280 7150 -4260 {
lab=VDD}
N 6920 -4100 7070 -4100 {
lab=q25}
N 7230 -4110 7350 -4110 {
lab=qb25}
N 7110 -4110 7230 -4110 {
lab=qb25}
N 6810 -4100 6860 -4100 {
lab=b25}
N 7410 -4110 7450 -4110 {
lab=blb25}
N 6890 -4320 6890 -4140 {
lab=WL}
N 6890 -4320 7380 -4320 {
lab=WL}
N 7380 -4320 7380 -4150 {
lab=WL}
N 6810 -4320 6890 -4320 {
lab=WL}
N 7070 -4100 7190 -4100 {
lab=q25}
N 7310 -4150 7310 -4110 {
lab=qb25}
N 6980 -4140 6980 -4100 {
lab=q25}
N 6330 -4060 6810 -4060 {
lab=b25}
N 6810 -4100 6810 -4060 {
lab=b25}
N 6320 -4080 6800 -4080 {
lab=blb25}
N 6800 -4080 6800 -3920 {
lab=blb25}
N 6800 -3920 7460 -3920 {
lab=blb25}
N 7460 -4110 7460 -3920 {
lab=blb25}
N 7450 -4110 7460 -4110 {
lab=blb25}
N 6390 -3650 6390 -3540 {
lab=blb25}
N 6310 -3680 6350 -3680 {
lab=d25}
N 6310 -3680 6310 -3510 {
lab=d25}
N 6310 -3510 6350 -3510 {
lab=d25}
N 6390 -3160 6390 -3120 {
lab=#net176}
N 6390 -3060 6390 -2950 {
lab=b25}
N 6390 -2890 6390 -2850 {
lab=#net177}
N 6310 -3090 6350 -3090 {
lab=#net178}
N 6310 -3090 6310 -2920 {
lab=#net178}
N 6310 -2920 6350 -2920 {
lab=#net178}
N 6140 -2820 6350 -2820 {
lab=we}
N 6070 -2820 6140 -2820 {
lab=we}
N 6070 -3620 6070 -2820 {
lab=we}
N 6070 -3630 6070 -3620 {
lab=we}
N 6070 -3630 6130 -3630 {
lab=we}
N 6070 -3410 6350 -3410 {
lab=we}
N 6080 -3600 6080 -3520 {
lab=d25}
N 6080 -3600 6310 -3600 {
lab=d25}
N 6080 -3530 6080 -3000 {
lab=d25}
N 6080 -3000 6110 -3000 {
lab=d25}
N 6170 -3000 6310 -3000 {
lab=#net178}
N 6390 -2790 6390 -2750 {
lab=GND}
N 6390 -3380 6390 -3340 {
lab=GND}
N 6390 -3850 6390 -3810 {
lab=VDD}
N 6390 -3240 6390 -3220 {
lab=VDD}
N 6390 -3600 6550 -3600 {
lab=blb25}
N 6390 -3010 6540 -3010 {
lab=b25}
N 6540 -3010 6550 -3010 {
lab=b25}
N 5990 -3630 6070 -3630 {
lab=we}
N 5990 -3000 6080 -3000 {
lab=d25}
N 6520 -4080 6520 -3600 {
lab=blb25}
N 6530 -4060 6530 -3010 {
lab=b25}
N 5980 -4210 5980 -4120 {
lab=b25}
N 5890 -4210 5980 -4210 {
lab=b25}
N 5980 -4060 5980 -3990 {
lab=blb25}
N 5890 -3990 5980 -3990 {
lab=blb25}
N 5790 -3990 5830 -3990 {
lab=VDD}
N 5790 -4210 5790 -3990 {
lab=VDD}
N 5790 -4210 5830 -4210 {
lab=VDD}
N 5940 -4090 5940 -3920 {
lab=p_b}
N 5790 -3990 5790 -3910 {
lab=VDD}
N 5980 -4210 6050 -4210 {
lab=b25}
N 5860 -4170 5860 -4030 {
lab=p_b}
N 5860 -4060 5940 -4060 {
lab=p_b}
N 6200 -4080 6300 -4080 {
lab=blb25}
N 6200 -4080 6200 -4000 {
lab=blb25}
N 5980 -4000 6200 -4000 {
lab=blb25}
N 6050 -4060 6300 -4060 {
lab=b25}
N 6050 -4210 6050 -4060 {
lab=b25}
N 7250 -3610 7340 -3610 {
lab=o25}
N 7340 -3700 7340 -3610 {
lab=o25}
N 7120 -3610 7190 -3610 {
lab=ob25}
N 7120 -3700 7120 -3610 {
lab=ob25}
N 7120 -3800 7120 -3760 {
lab=VDD}
N 7120 -3800 7340 -3800 {
lab=VDD}
N 7340 -3800 7340 -3760 {
lab=VDD}
N 7050 -3650 7220 -3650 {
lab=p_b}
N 7040 -3800 7120 -3800 {
lab=VDD}
N 7050 -3610 7120 -3610 {
lab=ob25}
N 7160 -3730 7300 -3730 {
lab=p_b}
N 7190 -3730 7190 -3650 {
lab=p_b}
N 7340 -3510 7340 -3490 {
lab=VDD}
N 7120 -3510 7340 -3510 {
lab=VDD}
N 7120 -3510 7120 -3500 {
lab=VDD}
N 7160 -3470 7260 -3470 {
lab=o25}
N 7260 -3470 7260 -3410 {
lab=o25}
N 7260 -3410 7340 -3410 {
lab=o25}
N 7340 -3430 7340 -3410 {
lab=o25}
N 7380 -3460 7410 -3460 {
lab=ob25}
N 7410 -3460 7410 -3390 {
lab=ob25}
N 7120 -3390 7410 -3390 {
lab=ob25}
N 7120 -3440 7120 -3390 {
lab=ob25}
N 7340 -3410 7340 -3330 {
lab=o25}
N 7120 -3390 7120 -3340 {
lab=ob25}
N 7120 -3280 7120 -3250 {
lab=#net179}
N 7120 -3250 7340 -3250 {
lab=#net179}
N 7340 -3270 7340 -3250 {
lab=#net179}
N 7210 -3250 7210 -3190 {
lab=#net179}
N 7210 -3130 7210 -3100 {
lab=GND}
N 7090 -3160 7170 -3160 {
lab=VDD}
N 7060 -3310 7080 -3310 {
lab=o25}
N 7060 -3410 7060 -3310 {
lab=o25}
N 7060 -3410 7180 -3410 {
lab=o25}
N 7180 -3470 7180 -3410 {
lab=o25}
N 7270 -3300 7300 -3300 {
lab=ob25}
N 7270 -3390 7270 -3300 {
lab=ob25}
N 7020 -3390 7120 -3390 {
lab=ob25}
N 7020 -3610 7020 -3390 {
lab=ob25}
N 7020 -3610 7060 -3610 {
lab=ob25}
N 7340 -3610 7450 -3610 {
lab=o25}
N 7450 -3610 7450 -3380 {
lab=o25}
N 7340 -3380 7450 -3380 {
lab=o25}
N 6900 -3390 7020 -3390 {
lab=ob25}
N 7450 -3380 7540 -3380 {
lab=o25}
N 6870 -3480 6870 -3430 {
lab=rd}
N 7570 -3460 7570 -3420 {
lab=rd}
N 7600 -3380 7670 -3380 {
lab=b25}
N 6780 -3390 6840 -3390 {
lab=blb25}
N 7490 -3450 7490 -3380 {
lab=o25}
N 6960 -3480 6960 -3390 {
lab=ob25}
N 6790 -3920 6790 -3390 {
lab=blb25}
N 6790 -3920 6800 -3920 {
lab=blb25}
N 7650 -3860 7650 -3380 {
lab=b25}
N 6810 -3860 7650 -3860 {
lab=b25}
N 6810 -4060 6810 -3860 {
lab=b25}
N 6630 -4090 6630 -4080 {
lab=blb25}
N 6590 -4090 6590 -4060 {
lab=b25}
N 6390 -3750 6390 -3710 {
lab=#net180}
N 6390 -3480 6390 -3440 {
lab=#net181}
N 6190 -3780 6350 -3780 {
lab=#net182}
N 6190 -3780 6190 -3630 {
lab=#net182}
N 6190 -3630 6190 -3190 {
lab=#net182}
N 6190 -3190 6350 -3190 {
lab=#net182}
N 8450 -4070 8470 -4070 {
lab=blb26}
N 8450 -4050 8480 -4050 {
lab=b26}
N 9220 -4160 9220 -4070 {
lab=q26}
N 9380 -4160 9380 -4070 {
lab=qb26}
N 9260 -4190 9260 -4040 {
lab=qb26}
N 9340 -4190 9340 -4040 {
lab=q26}
N 9220 -4250 9220 -4220 {
lab=VDD}
N 9220 -4250 9380 -4250 {
lab=VDD}
N 9380 -4250 9380 -4220 {
lab=VDD}
N 9220 -4010 9220 -3970 {
lab=GND}
N 9220 -3970 9380 -3970 {
lab=GND}
N 9380 -4010 9380 -3970 {
lab=GND}
N 9300 -3970 9300 -3950 {
lab=GND}
N 9300 -4270 9300 -4250 {
lab=VDD}
N 9070 -4090 9220 -4090 {
lab=q26}
N 9380 -4100 9500 -4100 {
lab=qb26}
N 9260 -4100 9380 -4100 {
lab=qb26}
N 8960 -4090 9010 -4090 {
lab=b26}
N 9560 -4100 9600 -4100 {
lab=blb26}
N 9040 -4310 9040 -4130 {
lab=WL}
N 9040 -4310 9530 -4310 {
lab=WL}
N 9530 -4310 9530 -4140 {
lab=WL}
N 8960 -4310 9040 -4310 {
lab=WL}
N 9220 -4090 9340 -4090 {
lab=q26}
N 9460 -4140 9460 -4100 {
lab=qb26}
N 9130 -4130 9130 -4090 {
lab=q26}
N 8480 -4050 8960 -4050 {
lab=b26}
N 8960 -4090 8960 -4050 {
lab=b26}
N 8470 -4070 8950 -4070 {
lab=blb26}
N 8950 -4070 8950 -3910 {
lab=blb26}
N 8950 -3910 9610 -3910 {
lab=blb26}
N 9610 -4100 9610 -3910 {
lab=blb26}
N 9600 -4100 9610 -4100 {
lab=blb26}
N 8540 -3640 8540 -3530 {
lab=blb26}
N 8460 -3670 8500 -3670 {
lab=d26}
N 8460 -3670 8460 -3500 {
lab=d26}
N 8460 -3500 8500 -3500 {
lab=d26}
N 8540 -3150 8540 -3110 {
lab=#net183}
N 8540 -3050 8540 -2940 {
lab=b26}
N 8540 -2880 8540 -2840 {
lab=#net184}
N 8460 -3080 8500 -3080 {
lab=#net185}
N 8460 -3080 8460 -2910 {
lab=#net185}
N 8460 -2910 8500 -2910 {
lab=#net185}
N 8290 -2810 8500 -2810 {
lab=we}
N 8220 -2810 8290 -2810 {
lab=we}
N 8220 -3610 8220 -2810 {
lab=we}
N 8220 -3620 8220 -3610 {
lab=we}
N 8220 -3620 8280 -3620 {
lab=we}
N 8220 -3400 8500 -3400 {
lab=we}
N 8230 -3590 8230 -3510 {
lab=d26}
N 8230 -3590 8460 -3590 {
lab=d26}
N 8230 -3520 8230 -2990 {
lab=d26}
N 8230 -2990 8260 -2990 {
lab=d26}
N 8320 -2990 8460 -2990 {
lab=#net185}
N 8540 -2780 8540 -2740 {
lab=GND}
N 8540 -3370 8540 -3330 {
lab=GND}
N 8540 -3840 8540 -3800 {
lab=VDD}
N 8540 -3230 8540 -3210 {
lab=VDD}
N 8540 -3590 8700 -3590 {
lab=blb26}
N 8540 -3000 8690 -3000 {
lab=b26}
N 8690 -3000 8700 -3000 {
lab=b26}
N 8140 -3620 8220 -3620 {
lab=we}
N 8140 -2990 8230 -2990 {
lab=d26}
N 8670 -4070 8670 -3590 {
lab=blb26}
N 8680 -4050 8680 -3000 {
lab=b26}
N 8130 -4200 8130 -4110 {
lab=b26}
N 8040 -4200 8130 -4200 {
lab=b26}
N 8130 -4050 8130 -3980 {
lab=blb26}
N 8040 -3980 8130 -3980 {
lab=blb26}
N 7940 -3980 7980 -3980 {
lab=VDD}
N 7940 -4200 7940 -3980 {
lab=VDD}
N 7940 -4200 7980 -4200 {
lab=VDD}
N 8090 -4080 8090 -3910 {
lab=p_b}
N 7940 -3980 7940 -3900 {
lab=VDD}
N 8130 -4200 8200 -4200 {
lab=b26}
N 8010 -4160 8010 -4020 {
lab=p_b}
N 8010 -4050 8090 -4050 {
lab=p_b}
N 8350 -4070 8450 -4070 {
lab=blb26}
N 8350 -4070 8350 -3990 {
lab=blb26}
N 8130 -3990 8350 -3990 {
lab=blb26}
N 8200 -4050 8450 -4050 {
lab=b26}
N 8200 -4200 8200 -4050 {
lab=b26}
N 9400 -3600 9490 -3600 {
lab=o26}
N 9490 -3690 9490 -3600 {
lab=o26}
N 9270 -3600 9340 -3600 {
lab=ob26}
N 9270 -3690 9270 -3600 {
lab=ob26}
N 9270 -3790 9270 -3750 {
lab=VDD}
N 9270 -3790 9490 -3790 {
lab=VDD}
N 9490 -3790 9490 -3750 {
lab=VDD}
N 9200 -3640 9370 -3640 {
lab=p_b}
N 9190 -3790 9270 -3790 {
lab=VDD}
N 9200 -3600 9270 -3600 {
lab=ob26}
N 9310 -3720 9450 -3720 {
lab=p_b}
N 9340 -3720 9340 -3640 {
lab=p_b}
N 9490 -3500 9490 -3480 {
lab=VDD}
N 9270 -3500 9490 -3500 {
lab=VDD}
N 9270 -3500 9270 -3490 {
lab=VDD}
N 9310 -3460 9410 -3460 {
lab=o26}
N 9410 -3460 9410 -3400 {
lab=o26}
N 9410 -3400 9490 -3400 {
lab=o26}
N 9490 -3420 9490 -3400 {
lab=o26}
N 9530 -3450 9560 -3450 {
lab=ob26}
N 9560 -3450 9560 -3380 {
lab=ob26}
N 9270 -3380 9560 -3380 {
lab=ob26}
N 9270 -3430 9270 -3380 {
lab=ob26}
N 9490 -3400 9490 -3320 {
lab=o26}
N 9270 -3380 9270 -3330 {
lab=ob26}
N 9270 -3270 9270 -3240 {
lab=#net186}
N 9270 -3240 9490 -3240 {
lab=#net186}
N 9490 -3260 9490 -3240 {
lab=#net186}
N 9360 -3240 9360 -3180 {
lab=#net186}
N 9360 -3120 9360 -3090 {
lab=GND}
N 9240 -3150 9320 -3150 {
lab=VDD}
N 9210 -3300 9230 -3300 {
lab=o26}
N 9210 -3400 9210 -3300 {
lab=o26}
N 9210 -3400 9330 -3400 {
lab=o26}
N 9330 -3460 9330 -3400 {
lab=o26}
N 9420 -3290 9450 -3290 {
lab=ob26}
N 9420 -3380 9420 -3290 {
lab=ob26}
N 9170 -3380 9270 -3380 {
lab=ob26}
N 9170 -3600 9170 -3380 {
lab=ob26}
N 9170 -3600 9210 -3600 {
lab=ob26}
N 9490 -3600 9600 -3600 {
lab=o26}
N 9600 -3600 9600 -3370 {
lab=o26}
N 9490 -3370 9600 -3370 {
lab=o26}
N 9050 -3380 9170 -3380 {
lab=ob26}
N 9600 -3370 9690 -3370 {
lab=o26}
N 9020 -3470 9020 -3420 {
lab=rd}
N 9720 -3450 9720 -3410 {
lab=rd}
N 9750 -3370 9820 -3370 {
lab=b26}
N 8930 -3380 8990 -3380 {
lab=blb26}
N 9640 -3440 9640 -3370 {
lab=o26}
N 9110 -3470 9110 -3380 {
lab=ob26}
N 8940 -3910 8940 -3380 {
lab=blb26}
N 8940 -3910 8950 -3910 {
lab=blb26}
N 9800 -3850 9800 -3370 {
lab=b26}
N 8960 -3850 9800 -3850 {
lab=b26}
N 8960 -4050 8960 -3850 {
lab=b26}
N 8780 -4080 8780 -4070 {
lab=blb26}
N 8740 -4080 8740 -4050 {
lab=b26}
N 8540 -3740 8540 -3700 {
lab=#net187}
N 8540 -3470 8540 -3430 {
lab=#net188}
N 8340 -3770 8500 -3770 {
lab=#net189}
N 8340 -3770 8340 -3620 {
lab=#net189}
N 8340 -3620 8340 -3180 {
lab=#net189}
N 8340 -3180 8500 -3180 {
lab=#net189}
N 10580 -4070 10600 -4070 {
lab=blb27}
N 10580 -4050 10610 -4050 {
lab=b27}
N 11350 -4160 11350 -4070 {
lab=q27}
N 11510 -4160 11510 -4070 {
lab=qb27}
N 11390 -4190 11390 -4040 {
lab=qb27}
N 11470 -4190 11470 -4040 {
lab=q27}
N 11350 -4250 11350 -4220 {
lab=VDD}
N 11350 -4250 11510 -4250 {
lab=VDD}
N 11510 -4250 11510 -4220 {
lab=VDD}
N 11350 -4010 11350 -3970 {
lab=GND}
N 11350 -3970 11510 -3970 {
lab=GND}
N 11510 -4010 11510 -3970 {
lab=GND}
N 11430 -3970 11430 -3950 {
lab=GND}
N 11430 -4270 11430 -4250 {
lab=VDD}
N 11200 -4090 11350 -4090 {
lab=q27}
N 11510 -4100 11630 -4100 {
lab=qb27}
N 11390 -4100 11510 -4100 {
lab=qb27}
N 11090 -4090 11140 -4090 {
lab=b27}
N 11690 -4100 11730 -4100 {
lab=blb27}
N 11170 -4310 11170 -4130 {
lab=WL}
N 11170 -4310 11660 -4310 {
lab=WL}
N 11660 -4310 11660 -4140 {
lab=WL}
N 11090 -4310 11170 -4310 {
lab=WL}
N 11350 -4090 11470 -4090 {
lab=q27}
N 11590 -4140 11590 -4100 {
lab=qb27}
N 11260 -4130 11260 -4090 {
lab=q27}
N 10610 -4050 11090 -4050 {
lab=b27}
N 11090 -4090 11090 -4050 {
lab=b27}
N 10600 -4070 11080 -4070 {
lab=blb27}
N 11080 -4070 11080 -3910 {
lab=blb27}
N 11080 -3910 11740 -3910 {
lab=blb27}
N 11740 -4100 11740 -3910 {
lab=blb27}
N 11730 -4100 11740 -4100 {
lab=blb27}
N 10670 -3640 10670 -3530 {
lab=blb27}
N 10590 -3670 10630 -3670 {
lab=d27}
N 10590 -3670 10590 -3500 {
lab=d27}
N 10590 -3500 10630 -3500 {
lab=d27}
N 10670 -3150 10670 -3110 {
lab=#net190}
N 10670 -3050 10670 -2940 {
lab=b27}
N 10670 -2880 10670 -2840 {
lab=#net191}
N 10590 -3080 10630 -3080 {
lab=#net192}
N 10590 -3080 10590 -2910 {
lab=#net192}
N 10590 -2910 10630 -2910 {
lab=#net192}
N 10420 -2810 10630 -2810 {
lab=we}
N 10350 -2810 10420 -2810 {
lab=we}
N 10350 -3610 10350 -2810 {
lab=we}
N 10350 -3620 10350 -3610 {
lab=we}
N 10350 -3620 10410 -3620 {
lab=we}
N 10350 -3400 10630 -3400 {
lab=we}
N 10360 -3590 10360 -3510 {
lab=d27}
N 10360 -3590 10590 -3590 {
lab=d27}
N 10360 -3520 10360 -2990 {
lab=d27}
N 10360 -2990 10390 -2990 {
lab=d27}
N 10450 -2990 10590 -2990 {
lab=#net192}
N 10670 -2780 10670 -2740 {
lab=GND}
N 10670 -3370 10670 -3330 {
lab=GND}
N 10670 -3840 10670 -3800 {
lab=VDD}
N 10670 -3230 10670 -3210 {
lab=VDD}
N 10670 -3590 10830 -3590 {
lab=blb27}
N 10670 -3000 10820 -3000 {
lab=b27}
N 10820 -3000 10830 -3000 {
lab=b27}
N 10270 -3620 10350 -3620 {
lab=we}
N 10270 -2990 10360 -2990 {
lab=d27}
N 10800 -4070 10800 -3590 {
lab=blb27}
N 10810 -4050 10810 -3000 {
lab=b27}
N 10260 -4200 10260 -4110 {
lab=b27}
N 10170 -4200 10260 -4200 {
lab=b27}
N 10260 -4050 10260 -3980 {
lab=blb27}
N 10170 -3980 10260 -3980 {
lab=blb27}
N 10070 -3980 10110 -3980 {
lab=VDD}
N 10070 -4200 10070 -3980 {
lab=VDD}
N 10070 -4200 10110 -4200 {
lab=VDD}
N 10220 -4080 10220 -3910 {
lab=p_b}
N 10070 -3980 10070 -3900 {
lab=VDD}
N 10260 -4200 10330 -4200 {
lab=b27}
N 10140 -4160 10140 -4020 {
lab=p_b}
N 10140 -4050 10220 -4050 {
lab=p_b}
N 10480 -4070 10580 -4070 {
lab=blb27}
N 10480 -4070 10480 -3990 {
lab=blb27}
N 10260 -3990 10480 -3990 {
lab=blb27}
N 10330 -4050 10580 -4050 {
lab=b27}
N 10330 -4200 10330 -4050 {
lab=b27}
N 11530 -3600 11620 -3600 {
lab=o27}
N 11620 -3690 11620 -3600 {
lab=o27}
N 11400 -3600 11470 -3600 {
lab=ob27}
N 11400 -3690 11400 -3600 {
lab=ob27}
N 11400 -3790 11400 -3750 {
lab=VDD}
N 11400 -3790 11620 -3790 {
lab=VDD}
N 11620 -3790 11620 -3750 {
lab=VDD}
N 11330 -3640 11500 -3640 {
lab=p_b}
N 11320 -3790 11400 -3790 {
lab=VDD}
N 11330 -3600 11400 -3600 {
lab=ob27}
N 11440 -3720 11580 -3720 {
lab=p_b}
N 11470 -3720 11470 -3640 {
lab=p_b}
N 11620 -3500 11620 -3480 {
lab=VDD}
N 11400 -3500 11620 -3500 {
lab=VDD}
N 11400 -3500 11400 -3490 {
lab=VDD}
N 11440 -3460 11540 -3460 {
lab=o27}
N 11540 -3460 11540 -3400 {
lab=o27}
N 11540 -3400 11620 -3400 {
lab=o27}
N 11620 -3420 11620 -3400 {
lab=o27}
N 11660 -3450 11690 -3450 {
lab=ob27}
N 11690 -3450 11690 -3380 {
lab=ob27}
N 11400 -3380 11690 -3380 {
lab=ob27}
N 11400 -3430 11400 -3380 {
lab=ob27}
N 11620 -3400 11620 -3320 {
lab=o27}
N 11400 -3380 11400 -3330 {
lab=ob27}
N 11400 -3270 11400 -3240 {
lab=#net193}
N 11400 -3240 11620 -3240 {
lab=#net193}
N 11620 -3260 11620 -3240 {
lab=#net193}
N 11490 -3240 11490 -3180 {
lab=#net193}
N 11490 -3120 11490 -3090 {
lab=GND}
N 11370 -3150 11450 -3150 {
lab=VDD}
N 11340 -3300 11360 -3300 {
lab=o27}
N 11340 -3400 11340 -3300 {
lab=o27}
N 11340 -3400 11460 -3400 {
lab=o27}
N 11460 -3460 11460 -3400 {
lab=o27}
N 11550 -3290 11580 -3290 {
lab=ob27}
N 11550 -3380 11550 -3290 {
lab=ob27}
N 11300 -3380 11400 -3380 {
lab=ob27}
N 11300 -3600 11300 -3380 {
lab=ob27}
N 11300 -3600 11340 -3600 {
lab=ob27}
N 11620 -3600 11730 -3600 {
lab=o27}
N 11730 -3600 11730 -3370 {
lab=o27}
N 11620 -3370 11730 -3370 {
lab=o27}
N 11180 -3380 11300 -3380 {
lab=ob27}
N 11730 -3370 11820 -3370 {
lab=o27}
N 11150 -3470 11150 -3420 {
lab=rd}
N 11850 -3450 11850 -3410 {
lab=rd}
N 11880 -3370 11950 -3370 {
lab=b27}
N 11060 -3380 11120 -3380 {
lab=blb27}
N 11770 -3440 11770 -3370 {
lab=o27}
N 11240 -3470 11240 -3380 {
lab=ob27}
N 11070 -3910 11070 -3380 {
lab=blb27}
N 11070 -3910 11080 -3910 {
lab=blb27}
N 11930 -3850 11930 -3370 {
lab=b27}
N 11090 -3850 11930 -3850 {
lab=b27}
N 11090 -4050 11090 -3850 {
lab=b27}
N 10910 -4080 10910 -4070 {
lab=blb27}
N 10870 -4080 10870 -4050 {
lab=b27}
N 10670 -3740 10670 -3700 {
lab=#net194}
N 10670 -3470 10670 -3430 {
lab=#net195}
N 10470 -3770 10630 -3770 {
lab=#net196}
N 10470 -3770 10470 -3620 {
lab=#net196}
N 10470 -3620 10470 -3180 {
lab=#net196}
N 10470 -3180 10630 -3180 {
lab=#net196}
N 12900 -4050 12920 -4050 {
lab=blb28}
N 12900 -4030 12930 -4030 {
lab=b28}
N 13670 -4140 13670 -4050 {
lab=q28}
N 13830 -4140 13830 -4050 {
lab=qb28}
N 13710 -4170 13710 -4020 {
lab=qb28}
N 13790 -4170 13790 -4020 {
lab=q28}
N 13670 -4230 13670 -4200 {
lab=VDD}
N 13670 -4230 13830 -4230 {
lab=VDD}
N 13830 -4230 13830 -4200 {
lab=VDD}
N 13670 -3990 13670 -3950 {
lab=GND}
N 13670 -3950 13830 -3950 {
lab=GND}
N 13830 -3990 13830 -3950 {
lab=GND}
N 13750 -3950 13750 -3930 {
lab=GND}
N 13750 -4250 13750 -4230 {
lab=VDD}
N 13520 -4070 13670 -4070 {
lab=q28}
N 13830 -4080 13950 -4080 {
lab=qb28}
N 13710 -4080 13830 -4080 {
lab=qb28}
N 13410 -4070 13460 -4070 {
lab=b28}
N 14010 -4080 14050 -4080 {
lab=blb28}
N 13490 -4290 13490 -4110 {
lab=WL}
N 13490 -4290 13980 -4290 {
lab=WL}
N 13980 -4290 13980 -4120 {
lab=WL}
N 13410 -4290 13490 -4290 {
lab=WL}
N 13670 -4070 13790 -4070 {
lab=q28}
N 13910 -4120 13910 -4080 {
lab=qb28}
N 13580 -4110 13580 -4070 {
lab=q28}
N 12930 -4030 13410 -4030 {
lab=b28}
N 13410 -4070 13410 -4030 {
lab=b28}
N 12920 -4050 13400 -4050 {
lab=blb28}
N 13400 -4050 13400 -3890 {
lab=blb28}
N 13400 -3890 14060 -3890 {
lab=blb28}
N 14060 -4080 14060 -3890 {
lab=blb28}
N 14050 -4080 14060 -4080 {
lab=blb28}
N 12990 -3620 12990 -3510 {
lab=blb28}
N 12910 -3650 12950 -3650 {
lab=d28}
N 12910 -3650 12910 -3480 {
lab=d28}
N 12910 -3480 12950 -3480 {
lab=d28}
N 12990 -3130 12990 -3090 {
lab=#net197}
N 12990 -3030 12990 -2920 {
lab=b28}
N 12990 -2860 12990 -2820 {
lab=#net198}
N 12910 -3060 12950 -3060 {
lab=#net199}
N 12910 -3060 12910 -2890 {
lab=#net199}
N 12910 -2890 12950 -2890 {
lab=#net199}
N 12740 -2790 12950 -2790 {
lab=we}
N 12670 -2790 12740 -2790 {
lab=we}
N 12670 -3590 12670 -2790 {
lab=we}
N 12670 -3600 12670 -3590 {
lab=we}
N 12670 -3600 12730 -3600 {
lab=we}
N 12670 -3380 12950 -3380 {
lab=we}
N 12680 -3570 12680 -3490 {
lab=d28}
N 12680 -3570 12910 -3570 {
lab=d28}
N 12680 -3500 12680 -2970 {
lab=d28}
N 12680 -2970 12710 -2970 {
lab=d28}
N 12770 -2970 12910 -2970 {
lab=#net199}
N 12990 -2760 12990 -2720 {
lab=GND}
N 12990 -3350 12990 -3310 {
lab=GND}
N 12990 -3820 12990 -3780 {
lab=VDD}
N 12990 -3210 12990 -3190 {
lab=VDD}
N 12990 -3570 13150 -3570 {
lab=blb28}
N 12990 -2980 13140 -2980 {
lab=b28}
N 13140 -2980 13150 -2980 {
lab=b28}
N 12590 -3600 12670 -3600 {
lab=we}
N 12590 -2970 12680 -2970 {
lab=d28}
N 13120 -4050 13120 -3570 {
lab=blb28}
N 13130 -4030 13130 -2980 {
lab=b28}
N 12580 -4180 12580 -4090 {
lab=b28}
N 12490 -4180 12580 -4180 {
lab=b28}
N 12580 -4030 12580 -3960 {
lab=blb28}
N 12490 -3960 12580 -3960 {
lab=blb28}
N 12390 -3960 12430 -3960 {
lab=VDD}
N 12390 -4180 12390 -3960 {
lab=VDD}
N 12390 -4180 12430 -4180 {
lab=VDD}
N 12540 -4060 12540 -3890 {
lab=p_b}
N 12390 -3960 12390 -3880 {
lab=VDD}
N 12580 -4180 12650 -4180 {
lab=b28}
N 12460 -4140 12460 -4000 {
lab=p_b}
N 12460 -4030 12540 -4030 {
lab=p_b}
N 12800 -4050 12900 -4050 {
lab=blb28}
N 12800 -4050 12800 -3970 {
lab=blb28}
N 12580 -3970 12800 -3970 {
lab=blb28}
N 12650 -4030 12900 -4030 {
lab=b28}
N 12650 -4180 12650 -4030 {
lab=b28}
N 13850 -3580 13940 -3580 {
lab=o28}
N 13940 -3670 13940 -3580 {
lab=o28}
N 13720 -3580 13790 -3580 {
lab=ob28}
N 13720 -3670 13720 -3580 {
lab=ob28}
N 13720 -3770 13720 -3730 {
lab=VDD}
N 13720 -3770 13940 -3770 {
lab=VDD}
N 13940 -3770 13940 -3730 {
lab=VDD}
N 13650 -3620 13820 -3620 {
lab=p_b}
N 13640 -3770 13720 -3770 {
lab=VDD}
N 13650 -3580 13720 -3580 {
lab=ob28}
N 13760 -3700 13900 -3700 {
lab=p_b}
N 13790 -3700 13790 -3620 {
lab=p_b}
N 13940 -3480 13940 -3460 {
lab=VDD}
N 13720 -3480 13940 -3480 {
lab=VDD}
N 13720 -3480 13720 -3470 {
lab=VDD}
N 13760 -3440 13860 -3440 {
lab=o28}
N 13860 -3440 13860 -3380 {
lab=o28}
N 13860 -3380 13940 -3380 {
lab=o28}
N 13940 -3400 13940 -3380 {
lab=o28}
N 13980 -3430 14010 -3430 {
lab=ob28}
N 14010 -3430 14010 -3360 {
lab=ob28}
N 13720 -3360 14010 -3360 {
lab=ob28}
N 13720 -3410 13720 -3360 {
lab=ob28}
N 13940 -3380 13940 -3300 {
lab=o28}
N 13720 -3360 13720 -3310 {
lab=ob28}
N 13720 -3250 13720 -3220 {
lab=#net200}
N 13720 -3220 13940 -3220 {
lab=#net200}
N 13940 -3240 13940 -3220 {
lab=#net200}
N 13810 -3220 13810 -3160 {
lab=#net200}
N 13810 -3100 13810 -3070 {
lab=GND}
N 13690 -3130 13770 -3130 {
lab=VDD}
N 13660 -3280 13680 -3280 {
lab=o28}
N 13660 -3380 13660 -3280 {
lab=o28}
N 13660 -3380 13780 -3380 {
lab=o28}
N 13780 -3440 13780 -3380 {
lab=o28}
N 13870 -3270 13900 -3270 {
lab=ob28}
N 13870 -3360 13870 -3270 {
lab=ob28}
N 13620 -3360 13720 -3360 {
lab=ob28}
N 13620 -3580 13620 -3360 {
lab=ob28}
N 13620 -3580 13660 -3580 {
lab=ob28}
N 13940 -3580 14050 -3580 {
lab=o28}
N 14050 -3580 14050 -3350 {
lab=o28}
N 13940 -3350 14050 -3350 {
lab=o28}
N 13500 -3360 13620 -3360 {
lab=ob28}
N 14050 -3350 14140 -3350 {
lab=o28}
N 13470 -3450 13470 -3400 {
lab=rd}
N 14170 -3430 14170 -3390 {
lab=rd}
N 14200 -3350 14270 -3350 {
lab=b28}
N 13380 -3360 13440 -3360 {
lab=blb28}
N 14090 -3420 14090 -3350 {
lab=o28}
N 13560 -3450 13560 -3360 {
lab=ob28}
N 13390 -3890 13390 -3360 {
lab=blb28}
N 13390 -3890 13400 -3890 {
lab=blb28}
N 14250 -3830 14250 -3350 {
lab=b28}
N 13410 -3830 14250 -3830 {
lab=b28}
N 13410 -4030 13410 -3830 {
lab=b28}
N 13230 -4060 13230 -4050 {
lab=blb28}
N 13190 -4060 13190 -4030 {
lab=b28}
N 12990 -3720 12990 -3680 {
lab=#net201}
N 12990 -3450 12990 -3410 {
lab=#net202}
N 12790 -3750 12950 -3750 {
lab=#net203}
N 12790 -3750 12790 -3600 {
lab=#net203}
N 12790 -3600 12790 -3160 {
lab=#net203}
N 12790 -3160 12950 -3160 {
lab=#net203}
N 15050 -4040 15070 -4040 {
lab=blb29}
N 15050 -4020 15080 -4020 {
lab=b29}
N 15820 -4130 15820 -4040 {
lab=q29}
N 15980 -4130 15980 -4040 {
lab=qb29}
N 15860 -4160 15860 -4010 {
lab=qb29}
N 15940 -4160 15940 -4010 {
lab=q29}
N 15820 -4220 15820 -4190 {
lab=VDD}
N 15820 -4220 15980 -4220 {
lab=VDD}
N 15980 -4220 15980 -4190 {
lab=VDD}
N 15820 -3980 15820 -3940 {
lab=GND}
N 15820 -3940 15980 -3940 {
lab=GND}
N 15980 -3980 15980 -3940 {
lab=GND}
N 15900 -3940 15900 -3920 {
lab=GND}
N 15900 -4240 15900 -4220 {
lab=VDD}
N 15670 -4060 15820 -4060 {
lab=q29}
N 15980 -4070 16100 -4070 {
lab=qb29}
N 15860 -4070 15980 -4070 {
lab=qb29}
N 15560 -4060 15610 -4060 {
lab=b29}
N 16160 -4070 16200 -4070 {
lab=blb29}
N 15640 -4280 15640 -4100 {
lab=WL}
N 15640 -4280 16130 -4280 {
lab=WL}
N 16130 -4280 16130 -4110 {
lab=WL}
N 15560 -4280 15640 -4280 {
lab=WL}
N 15820 -4060 15940 -4060 {
lab=q29}
N 16060 -4110 16060 -4070 {
lab=qb29}
N 15730 -4100 15730 -4060 {
lab=q29}
N 15080 -4020 15560 -4020 {
lab=b29}
N 15560 -4060 15560 -4020 {
lab=b29}
N 15070 -4040 15550 -4040 {
lab=blb29}
N 15550 -4040 15550 -3880 {
lab=blb29}
N 15550 -3880 16210 -3880 {
lab=blb29}
N 16210 -4070 16210 -3880 {
lab=blb29}
N 16200 -4070 16210 -4070 {
lab=blb29}
N 15140 -3610 15140 -3500 {
lab=blb29}
N 15060 -3640 15100 -3640 {
lab=d29}
N 15060 -3640 15060 -3470 {
lab=d29}
N 15060 -3470 15100 -3470 {
lab=d29}
N 15140 -3120 15140 -3080 {
lab=#net204}
N 15140 -3020 15140 -2910 {
lab=b29}
N 15140 -2850 15140 -2810 {
lab=#net205}
N 15060 -3050 15100 -3050 {
lab=#net206}
N 15060 -3050 15060 -2880 {
lab=#net206}
N 15060 -2880 15100 -2880 {
lab=#net206}
N 14890 -2780 15100 -2780 {
lab=we}
N 14820 -2780 14890 -2780 {
lab=we}
N 14820 -3580 14820 -2780 {
lab=we}
N 14820 -3590 14820 -3580 {
lab=we}
N 14820 -3590 14880 -3590 {
lab=we}
N 14820 -3370 15100 -3370 {
lab=we}
N 14830 -3560 14830 -3480 {
lab=d29}
N 14830 -3560 15060 -3560 {
lab=d29}
N 14830 -3490 14830 -2960 {
lab=d29}
N 14830 -2960 14860 -2960 {
lab=d29}
N 14920 -2960 15060 -2960 {
lab=#net206}
N 15140 -2750 15140 -2710 {
lab=GND}
N 15140 -3340 15140 -3300 {
lab=GND}
N 15140 -3810 15140 -3770 {
lab=VDD}
N 15140 -3200 15140 -3180 {
lab=VDD}
N 15140 -3560 15300 -3560 {
lab=blb29}
N 15140 -2970 15290 -2970 {
lab=b29}
N 15290 -2970 15300 -2970 {
lab=b29}
N 14740 -3590 14820 -3590 {
lab=we}
N 14740 -2960 14830 -2960 {
lab=d29}
N 15270 -4040 15270 -3560 {
lab=blb29}
N 15280 -4020 15280 -2970 {
lab=b29}
N 14730 -4170 14730 -4080 {
lab=b29}
N 14640 -4170 14730 -4170 {
lab=b29}
N 14730 -4020 14730 -3950 {
lab=blb29}
N 14640 -3950 14730 -3950 {
lab=blb29}
N 14540 -3950 14580 -3950 {
lab=VDD}
N 14540 -4170 14540 -3950 {
lab=VDD}
N 14540 -4170 14580 -4170 {
lab=VDD}
N 14690 -4050 14690 -3880 {
lab=p_b}
N 14540 -3950 14540 -3870 {
lab=VDD}
N 14730 -4170 14800 -4170 {
lab=b29}
N 14610 -4130 14610 -3990 {
lab=p_b}
N 14610 -4020 14690 -4020 {
lab=p_b}
N 14950 -4040 15050 -4040 {
lab=blb29}
N 14950 -4040 14950 -3960 {
lab=blb29}
N 14730 -3960 14950 -3960 {
lab=blb29}
N 14800 -4020 15050 -4020 {
lab=b29}
N 14800 -4170 14800 -4020 {
lab=b29}
N 16000 -3570 16090 -3570 {
lab=o29}
N 16090 -3660 16090 -3570 {
lab=o29}
N 15870 -3570 15940 -3570 {
lab=ob29}
N 15870 -3660 15870 -3570 {
lab=ob29}
N 15870 -3760 15870 -3720 {
lab=VDD}
N 15870 -3760 16090 -3760 {
lab=VDD}
N 16090 -3760 16090 -3720 {
lab=VDD}
N 15800 -3610 15970 -3610 {
lab=p_b}
N 15790 -3760 15870 -3760 {
lab=VDD}
N 15800 -3570 15870 -3570 {
lab=ob29}
N 15910 -3690 16050 -3690 {
lab=p_b}
N 15940 -3690 15940 -3610 {
lab=p_b}
N 16090 -3470 16090 -3450 {
lab=VDD}
N 15870 -3470 16090 -3470 {
lab=VDD}
N 15870 -3470 15870 -3460 {
lab=VDD}
N 15910 -3430 16010 -3430 {
lab=o29}
N 16010 -3430 16010 -3370 {
lab=o29}
N 16010 -3370 16090 -3370 {
lab=o29}
N 16090 -3390 16090 -3370 {
lab=o29}
N 16130 -3420 16160 -3420 {
lab=ob29}
N 16160 -3420 16160 -3350 {
lab=ob29}
N 15870 -3350 16160 -3350 {
lab=ob29}
N 15870 -3400 15870 -3350 {
lab=ob29}
N 16090 -3370 16090 -3290 {
lab=o29}
N 15870 -3350 15870 -3300 {
lab=ob29}
N 15870 -3240 15870 -3210 {
lab=#net207}
N 15870 -3210 16090 -3210 {
lab=#net207}
N 16090 -3230 16090 -3210 {
lab=#net207}
N 15960 -3210 15960 -3150 {
lab=#net207}
N 15960 -3090 15960 -3060 {
lab=GND}
N 15840 -3120 15920 -3120 {
lab=VDD}
N 15810 -3270 15830 -3270 {
lab=o29}
N 15810 -3370 15810 -3270 {
lab=o29}
N 15810 -3370 15930 -3370 {
lab=o29}
N 15930 -3430 15930 -3370 {
lab=o29}
N 16020 -3260 16050 -3260 {
lab=ob29}
N 16020 -3350 16020 -3260 {
lab=ob29}
N 15770 -3350 15870 -3350 {
lab=ob29}
N 15770 -3570 15770 -3350 {
lab=ob29}
N 15770 -3570 15810 -3570 {
lab=ob29}
N 16090 -3570 16200 -3570 {
lab=o29}
N 16200 -3570 16200 -3340 {
lab=o29}
N 16090 -3340 16200 -3340 {
lab=o29}
N 15650 -3350 15770 -3350 {
lab=ob29}
N 16200 -3340 16290 -3340 {
lab=o29}
N 15620 -3440 15620 -3390 {
lab=rd}
N 16320 -3420 16320 -3380 {
lab=rd}
N 16350 -3340 16420 -3340 {
lab=b29}
N 15530 -3350 15590 -3350 {
lab=blb29}
N 16240 -3410 16240 -3340 {
lab=o29}
N 15710 -3440 15710 -3350 {
lab=ob29}
N 15540 -3880 15540 -3350 {
lab=blb29}
N 15540 -3880 15550 -3880 {
lab=blb29}
N 16400 -3820 16400 -3340 {
lab=b29}
N 15560 -3820 16400 -3820 {
lab=b29}
N 15560 -4020 15560 -3820 {
lab=b29}
N 15380 -4050 15380 -4040 {
lab=blb29}
N 15340 -4050 15340 -4020 {
lab=b29}
N 15140 -3710 15140 -3670 {
lab=#net208}
N 15140 -3440 15140 -3400 {
lab=#net209}
N 14940 -3740 15100 -3740 {
lab=#net210}
N 14940 -3740 14940 -3590 {
lab=#net210}
N 14940 -3590 14940 -3150 {
lab=#net210}
N 14940 -3150 15100 -3150 {
lab=#net210}
N 4350 -1730 4370 -1730 {
lab=blb30}
N 4350 -1710 4380 -1710 {
lab=b30}
N 5120 -1820 5120 -1730 {
lab=q30}
N 5280 -1820 5280 -1730 {
lab=qb30}
N 5160 -1850 5160 -1700 {
lab=qb30}
N 5240 -1850 5240 -1700 {
lab=q30}
N 5120 -1910 5120 -1880 {
lab=VDD}
N 5120 -1910 5280 -1910 {
lab=VDD}
N 5280 -1910 5280 -1880 {
lab=VDD}
N 5120 -1670 5120 -1630 {
lab=GND}
N 5120 -1630 5280 -1630 {
lab=GND}
N 5280 -1670 5280 -1630 {
lab=GND}
N 5200 -1630 5200 -1610 {
lab=GND}
N 5200 -1930 5200 -1910 {
lab=VDD}
N 4970 -1750 5120 -1750 {
lab=q30}
N 5280 -1760 5400 -1760 {
lab=qb30}
N 5160 -1760 5280 -1760 {
lab=qb30}
N 4860 -1750 4910 -1750 {
lab=b30}
N 5460 -1760 5500 -1760 {
lab=blb30}
N 4940 -1970 4940 -1790 {
lab=WL}
N 4940 -1970 5430 -1970 {
lab=WL}
N 5430 -1970 5430 -1800 {
lab=WL}
N 4860 -1970 4940 -1970 {
lab=WL}
N 5120 -1750 5240 -1750 {
lab=q30}
N 5360 -1800 5360 -1760 {
lab=qb30}
N 5030 -1790 5030 -1750 {
lab=q30}
N 4380 -1710 4860 -1710 {
lab=b30}
N 4860 -1750 4860 -1710 {
lab=b30}
N 4370 -1730 4850 -1730 {
lab=blb30}
N 4850 -1730 4850 -1570 {
lab=blb30}
N 4850 -1570 5510 -1570 {
lab=blb30}
N 5510 -1760 5510 -1570 {
lab=blb30}
N 5500 -1760 5510 -1760 {
lab=blb30}
N 4440 -1300 4440 -1190 {
lab=blb30}
N 4360 -1330 4400 -1330 {
lab=d30}
N 4360 -1330 4360 -1160 {
lab=d30}
N 4360 -1160 4400 -1160 {
lab=d30}
N 4440 -810 4440 -770 {
lab=#net211}
N 4440 -710 4440 -600 {
lab=b30}
N 4440 -540 4440 -500 {
lab=#net212}
N 4360 -740 4400 -740 {
lab=#net213}
N 4360 -740 4360 -570 {
lab=#net213}
N 4360 -570 4400 -570 {
lab=#net213}
N 4190 -470 4400 -470 {
lab=we}
N 4120 -470 4190 -470 {
lab=we}
N 4120 -1270 4120 -470 {
lab=we}
N 4120 -1280 4120 -1270 {
lab=we}
N 4120 -1280 4180 -1280 {
lab=we}
N 4120 -1060 4400 -1060 {
lab=we}
N 4130 -1250 4130 -1170 {
lab=d30}
N 4130 -1250 4360 -1250 {
lab=d30}
N 4130 -1180 4130 -650 {
lab=d30}
N 4130 -650 4160 -650 {
lab=d30}
N 4220 -650 4360 -650 {
lab=#net213}
N 4440 -440 4440 -400 {
lab=GND}
N 4440 -1030 4440 -990 {
lab=GND}
N 4440 -1500 4440 -1460 {
lab=VDD}
N 4440 -890 4440 -870 {
lab=VDD}
N 4440 -1250 4600 -1250 {
lab=blb30}
N 4440 -660 4590 -660 {
lab=b30}
N 4590 -660 4600 -660 {
lab=b30}
N 4040 -1280 4120 -1280 {
lab=we}
N 4040 -650 4130 -650 {
lab=d30}
N 4570 -1730 4570 -1250 {
lab=blb30}
N 4580 -1710 4580 -660 {
lab=b30}
N 4030 -1860 4030 -1770 {
lab=b30}
N 3940 -1860 4030 -1860 {
lab=b30}
N 4030 -1710 4030 -1640 {
lab=blb30}
N 3940 -1640 4030 -1640 {
lab=blb30}
N 3840 -1640 3880 -1640 {
lab=VDD}
N 3840 -1860 3840 -1640 {
lab=VDD}
N 3840 -1860 3880 -1860 {
lab=VDD}
N 3990 -1740 3990 -1570 {
lab=p_b}
N 3840 -1640 3840 -1560 {
lab=VDD}
N 4030 -1860 4100 -1860 {
lab=b30}
N 3910 -1820 3910 -1680 {
lab=p_b}
N 3910 -1710 3990 -1710 {
lab=p_b}
N 4250 -1730 4350 -1730 {
lab=blb30}
N 4250 -1730 4250 -1650 {
lab=blb30}
N 4030 -1650 4250 -1650 {
lab=blb30}
N 4100 -1710 4350 -1710 {
lab=b30}
N 4100 -1860 4100 -1710 {
lab=b30}
N 5300 -1260 5390 -1260 {
lab=o30}
N 5390 -1350 5390 -1260 {
lab=o30}
N 5170 -1260 5240 -1260 {
lab=ob30}
N 5170 -1350 5170 -1260 {
lab=ob30}
N 5170 -1450 5170 -1410 {
lab=VDD}
N 5170 -1450 5390 -1450 {
lab=VDD}
N 5390 -1450 5390 -1410 {
lab=VDD}
N 5100 -1300 5270 -1300 {
lab=p_b}
N 5090 -1450 5170 -1450 {
lab=VDD}
N 5100 -1260 5170 -1260 {
lab=ob30}
N 5210 -1380 5350 -1380 {
lab=p_b}
N 5240 -1380 5240 -1300 {
lab=p_b}
N 5390 -1160 5390 -1140 {
lab=VDD}
N 5170 -1160 5390 -1160 {
lab=VDD}
N 5170 -1160 5170 -1150 {
lab=VDD}
N 5210 -1120 5310 -1120 {
lab=o30}
N 5310 -1120 5310 -1060 {
lab=o30}
N 5310 -1060 5390 -1060 {
lab=o30}
N 5390 -1080 5390 -1060 {
lab=o30}
N 5430 -1110 5460 -1110 {
lab=ob30}
N 5460 -1110 5460 -1040 {
lab=ob30}
N 5170 -1040 5460 -1040 {
lab=ob30}
N 5170 -1090 5170 -1040 {
lab=ob30}
N 5390 -1060 5390 -980 {
lab=o30}
N 5170 -1040 5170 -990 {
lab=ob30}
N 5170 -930 5170 -900 {
lab=#net214}
N 5170 -900 5390 -900 {
lab=#net214}
N 5390 -920 5390 -900 {
lab=#net214}
N 5260 -900 5260 -840 {
lab=#net214}
N 5260 -780 5260 -750 {
lab=GND}
N 5140 -810 5220 -810 {
lab=VDD}
N 5110 -960 5130 -960 {
lab=o30}
N 5110 -1060 5110 -960 {
lab=o30}
N 5110 -1060 5230 -1060 {
lab=o30}
N 5230 -1120 5230 -1060 {
lab=o30}
N 5320 -950 5350 -950 {
lab=ob30}
N 5320 -1040 5320 -950 {
lab=ob30}
N 5070 -1040 5170 -1040 {
lab=ob30}
N 5070 -1260 5070 -1040 {
lab=ob30}
N 5070 -1260 5110 -1260 {
lab=ob30}
N 5390 -1260 5500 -1260 {
lab=o30}
N 5500 -1260 5500 -1030 {
lab=o30}
N 5390 -1030 5500 -1030 {
lab=o30}
N 4950 -1040 5070 -1040 {
lab=ob30}
N 5500 -1030 5590 -1030 {
lab=o30}
N 4920 -1130 4920 -1080 {
lab=rd}
N 5620 -1110 5620 -1070 {
lab=rd}
N 5650 -1030 5720 -1030 {
lab=b30}
N 4830 -1040 4890 -1040 {
lab=blb30}
N 5540 -1100 5540 -1030 {
lab=o30}
N 5010 -1130 5010 -1040 {
lab=ob30}
N 4840 -1570 4840 -1040 {
lab=blb30}
N 4840 -1570 4850 -1570 {
lab=blb30}
N 5700 -1510 5700 -1030 {
lab=b30}
N 4860 -1510 5700 -1510 {
lab=b30}
N 4860 -1710 4860 -1510 {
lab=b30}
N 4680 -1740 4680 -1730 {
lab=blb30}
N 4640 -1740 4640 -1710 {
lab=b30}
N 4440 -1400 4440 -1360 {
lab=#net215}
N 4440 -1130 4440 -1090 {
lab=#net216}
N 4240 -1430 4400 -1430 {
lab=#net217}
N 4240 -1430 4240 -1280 {
lab=#net217}
N 4240 -1280 4240 -840 {
lab=#net217}
N 4240 -840 4400 -840 {
lab=#net217}
N 6500 -1720 6520 -1720 {
lab=blb31}
N 6500 -1700 6530 -1700 {
lab=b31}
N 7270 -1810 7270 -1720 {
lab=q31}
N 7430 -1810 7430 -1720 {
lab=qb31}
N 7310 -1840 7310 -1690 {
lab=qb31}
N 7390 -1840 7390 -1690 {
lab=q31}
N 7270 -1900 7270 -1870 {
lab=VDD}
N 7270 -1900 7430 -1900 {
lab=VDD}
N 7430 -1900 7430 -1870 {
lab=VDD}
N 7270 -1660 7270 -1620 {
lab=GND}
N 7270 -1620 7430 -1620 {
lab=GND}
N 7430 -1660 7430 -1620 {
lab=GND}
N 7350 -1620 7350 -1600 {
lab=GND}
N 7350 -1920 7350 -1900 {
lab=VDD}
N 7120 -1740 7270 -1740 {
lab=q31}
N 7430 -1750 7550 -1750 {
lab=qb31}
N 7310 -1750 7430 -1750 {
lab=qb31}
N 7010 -1740 7060 -1740 {
lab=b31}
N 7610 -1750 7650 -1750 {
lab=blb31}
N 7090 -1960 7090 -1780 {
lab=WL}
N 7090 -1960 7580 -1960 {
lab=WL}
N 7580 -1960 7580 -1790 {
lab=WL}
N 7010 -1960 7090 -1960 {
lab=WL}
N 7270 -1740 7390 -1740 {
lab=q31}
N 7510 -1790 7510 -1750 {
lab=qb31}
N 7180 -1780 7180 -1740 {
lab=q31}
N 6530 -1700 7010 -1700 {
lab=b31}
N 7010 -1740 7010 -1700 {
lab=b31}
N 6520 -1720 7000 -1720 {
lab=blb31}
N 7000 -1720 7000 -1560 {
lab=blb31}
N 7000 -1560 7660 -1560 {
lab=blb31}
N 7660 -1750 7660 -1560 {
lab=blb31}
N 7650 -1750 7660 -1750 {
lab=blb31}
N 6590 -1290 6590 -1180 {
lab=blb31}
N 6510 -1320 6550 -1320 {
lab=d31}
N 6510 -1320 6510 -1150 {
lab=d31}
N 6510 -1150 6550 -1150 {
lab=d31}
N 6590 -800 6590 -760 {
lab=#net218}
N 6590 -700 6590 -590 {
lab=b31}
N 6590 -530 6590 -490 {
lab=#net219}
N 6510 -730 6550 -730 {
lab=#net220}
N 6510 -730 6510 -560 {
lab=#net220}
N 6510 -560 6550 -560 {
lab=#net220}
N 6340 -460 6550 -460 {
lab=we}
N 6270 -460 6340 -460 {
lab=we}
N 6270 -1260 6270 -460 {
lab=we}
N 6270 -1270 6270 -1260 {
lab=we}
N 6270 -1270 6330 -1270 {
lab=we}
N 6270 -1050 6550 -1050 {
lab=we}
N 6280 -1240 6280 -1160 {
lab=d31}
N 6280 -1240 6510 -1240 {
lab=d31}
N 6280 -1170 6280 -640 {
lab=d31}
N 6280 -640 6310 -640 {
lab=d31}
N 6370 -640 6510 -640 {
lab=#net220}
N 6590 -430 6590 -390 {
lab=GND}
N 6590 -1020 6590 -980 {
lab=GND}
N 6590 -1490 6590 -1450 {
lab=VDD}
N 6590 -880 6590 -860 {
lab=VDD}
N 6590 -1240 6750 -1240 {
lab=blb31}
N 6590 -650 6740 -650 {
lab=b31}
N 6740 -650 6750 -650 {
lab=b31}
N 6190 -1270 6270 -1270 {
lab=we}
N 6190 -640 6280 -640 {
lab=d31}
N 6720 -1720 6720 -1240 {
lab=blb31}
N 6730 -1700 6730 -650 {
lab=b31}
N 6180 -1850 6180 -1760 {
lab=b31}
N 6090 -1850 6180 -1850 {
lab=b31}
N 6180 -1700 6180 -1630 {
lab=blb31}
N 6090 -1630 6180 -1630 {
lab=blb31}
N 5990 -1630 6030 -1630 {
lab=VDD}
N 5990 -1850 5990 -1630 {
lab=VDD}
N 5990 -1850 6030 -1850 {
lab=VDD}
N 6140 -1730 6140 -1560 {
lab=p_b}
N 5990 -1630 5990 -1550 {
lab=VDD}
N 6180 -1850 6250 -1850 {
lab=b31}
N 6060 -1810 6060 -1670 {
lab=p_b}
N 6060 -1700 6140 -1700 {
lab=p_b}
N 6400 -1720 6500 -1720 {
lab=blb31}
N 6400 -1720 6400 -1640 {
lab=blb31}
N 6180 -1640 6400 -1640 {
lab=blb31}
N 6250 -1700 6500 -1700 {
lab=b31}
N 6250 -1850 6250 -1700 {
lab=b31}
N 7450 -1250 7540 -1250 {
lab=o31}
N 7540 -1340 7540 -1250 {
lab=o31}
N 7320 -1250 7390 -1250 {
lab=ob31}
N 7320 -1340 7320 -1250 {
lab=ob31}
N 7320 -1440 7320 -1400 {
lab=VDD}
N 7320 -1440 7540 -1440 {
lab=VDD}
N 7540 -1440 7540 -1400 {
lab=VDD}
N 7250 -1290 7420 -1290 {
lab=p_b}
N 7240 -1440 7320 -1440 {
lab=VDD}
N 7250 -1250 7320 -1250 {
lab=ob31}
N 7360 -1370 7500 -1370 {
lab=p_b}
N 7390 -1370 7390 -1290 {
lab=p_b}
N 7540 -1150 7540 -1130 {
lab=VDD}
N 7320 -1150 7540 -1150 {
lab=VDD}
N 7320 -1150 7320 -1140 {
lab=VDD}
N 7360 -1110 7460 -1110 {
lab=o31}
N 7460 -1110 7460 -1050 {
lab=o31}
N 7460 -1050 7540 -1050 {
lab=o31}
N 7540 -1070 7540 -1050 {
lab=o31}
N 7580 -1100 7610 -1100 {
lab=ob31}
N 7610 -1100 7610 -1030 {
lab=ob31}
N 7320 -1030 7610 -1030 {
lab=ob31}
N 7320 -1080 7320 -1030 {
lab=ob31}
N 7540 -1050 7540 -970 {
lab=o31}
N 7320 -1030 7320 -980 {
lab=ob31}
N 7320 -920 7320 -890 {
lab=#net221}
N 7320 -890 7540 -890 {
lab=#net221}
N 7540 -910 7540 -890 {
lab=#net221}
N 7410 -890 7410 -830 {
lab=#net221}
N 7410 -770 7410 -740 {
lab=GND}
N 7290 -800 7370 -800 {
lab=VDD}
N 7260 -950 7280 -950 {
lab=o31}
N 7260 -1050 7260 -950 {
lab=o31}
N 7260 -1050 7380 -1050 {
lab=o31}
N 7380 -1110 7380 -1050 {
lab=o31}
N 7470 -940 7500 -940 {
lab=ob31}
N 7470 -1030 7470 -940 {
lab=ob31}
N 7220 -1030 7320 -1030 {
lab=ob31}
N 7220 -1250 7220 -1030 {
lab=ob31}
N 7220 -1250 7260 -1250 {
lab=ob31}
N 7540 -1250 7650 -1250 {
lab=o31}
N 7650 -1250 7650 -1020 {
lab=o31}
N 7540 -1020 7650 -1020 {
lab=o31}
N 7100 -1030 7220 -1030 {
lab=ob31}
N 7650 -1020 7740 -1020 {
lab=o31}
N 7070 -1120 7070 -1070 {
lab=rd}
N 7770 -1100 7770 -1060 {
lab=rd}
N 7800 -1020 7870 -1020 {
lab=b31}
N 6980 -1030 7040 -1030 {
lab=blb31}
N 7690 -1090 7690 -1020 {
lab=o31}
N 7160 -1120 7160 -1030 {
lab=ob31}
N 6990 -1560 6990 -1030 {
lab=blb31}
N 6990 -1560 7000 -1560 {
lab=blb31}
N 7850 -1500 7850 -1020 {
lab=b31}
N 7010 -1500 7850 -1500 {
lab=b31}
N 7010 -1700 7010 -1500 {
lab=b31}
N 6830 -1730 6830 -1720 {
lab=blb31}
N 6790 -1730 6790 -1700 {
lab=b31}
N 6590 -1390 6590 -1350 {
lab=#net222}
N 6590 -1120 6590 -1080 {
lab=#net223}
N 6390 -1420 6550 -1420 {
lab=#net224}
N 6390 -1420 6390 -1270 {
lab=#net224}
N 6390 -1270 6390 -830 {
lab=#net224}
N 6390 -830 6550 -830 {
lab=#net224}
N 17630 -9420 17631.46728515625 -9408.88671875 {
lab=d0}
N 17630 -9270 17631.46728515625 -9258.88671875 {
lab=d3}
N 17630 -9160 17630 -9140 {
lab=d6}
N 18040 -9400 18041.46728515625 -9378.88671875 {
lab=d1}
N 18050 -9260 18051.46728515625 -9238.88671875 {
lab=d4}
N 18310 -9310 18311.46728515625 -9298.88671875 {
lab=d2}
C {devices/opin.sym} 4460 -12660 3 0 {name=p33 sig_type=std_logic lab=o0}
C {devices/opin.sym} 3930 -12690 3 0 {name=p34 sig_type=std_logic lab=ob0}
C {devices/opin.sym} 3600 -13300 3 0 {name=p35 sig_type=std_logic lab=blb0}
C {devices/opin.sym} 3560 -13300 3 0 {name=p36 sig_type=std_logic lab=b0}
C {devices/opin.sym} 3950 -13350 0 1 {name=p37 sig_type=std_logic lab=q0}
C {devices/opin.sym} 4280 -13360 3 0 {name=p38 sig_type=std_logic lab=qb0}
C {devices/opin.sym} 6780 -12640 3 0 {name=p39 sig_type=std_logic lab=o1}
C {devices/opin.sym} 6250 -12670 3 0 {name=p40 sig_type=std_logic lab=ob1}
C {devices/opin.sym} 5920 -13280 3 0 {name=p41 sig_type=std_logic lab=blb1}
C {devices/opin.sym} 5880 -13280 3 0 {name=p42 sig_type=std_logic lab=b1}
C {devices/opin.sym} 6270 -13330 3 0 {name=p43 sig_type=std_logic lab=q1}
C {devices/opin.sym} 6600 -13340 3 0 {name=p44 sig_type=std_logic lab=qb1}
C {devices/opin.sym} 8930 -12630 3 0 {name=p45 sig_type=std_logic lab=o2}
C {devices/opin.sym} 8400 -12660 3 0 {name=p46 sig_type=std_logic lab=ob2}
C {devices/opin.sym} 8070 -13270 3 0 {name=p47 sig_type=std_logic lab=blb2}
C {devices/opin.sym} 8030 -13270 3 0 {name=p48 sig_type=std_logic lab=b2}
C {devices/opin.sym} 8420 -13320 3 0 {name=p49 sig_type=std_logic lab=q2}
C {devices/opin.sym} 8750 -13330 3 0 {name=p50 sig_type=std_logic lab=qb2}
C {devices/opin.sym} 11060 -12630 3 0 {name=p51 sig_type=std_logic lab=o3}
C {devices/opin.sym} 10530 -12660 3 0 {name=p52 sig_type=std_logic lab=ob3}
C {devices/opin.sym} 10200 -13270 3 0 {name=p53 sig_type=std_logic lab=blb3}
C {devices/opin.sym} 10160 -13270 3 0 {name=p54 sig_type=std_logic lab=b3}
C {devices/opin.sym} 10550 -13320 3 0 {name=p55 sig_type=std_logic lab=q3}
C {devices/opin.sym} 10880 -13330 3 0 {name=p56 sig_type=std_logic lab=qb3}
C {devices/opin.sym} 13380 -12610 3 0 {name=p57 sig_type=std_logic lab=o4}
C {devices/opin.sym} 12850 -12640 3 0 {name=p58 sig_type=std_logic lab=ob4}
C {devices/opin.sym} 12520 -13250 3 0 {name=p59 sig_type=std_logic lab=blb4}
C {devices/opin.sym} 12480 -13250 3 0 {name=p60 sig_type=std_logic lab=b4}
C {devices/opin.sym} 12870 -13300 3 0 {name=p61 sig_type=std_logic lab=q4}
C {devices/opin.sym} 13200 -13310 3 0 {name=p62 sig_type=std_logic lab=qb4}
C {devices/opin.sym} 15530 -12600 3 0 {name=p63 sig_type=std_logic lab=o5}
C {devices/opin.sym} 15000 -12630 3 0 {name=p64 sig_type=std_logic lab=ob5}
C {devices/opin.sym} 14670 -13240 3 0 {name=p65 sig_type=std_logic lab=blb5}
C {devices/opin.sym} 14630 -13240 3 0 {name=p66 sig_type=std_logic lab=b5}
C {devices/opin.sym} 15020 -13290 3 0 {name=p67 sig_type=std_logic lab=q5}
C {devices/opin.sym} 15350 -13300 3 0 {name=p68 sig_type=std_logic lab=qb5}
C {devices/code_shown.sym} 18580 -7275 0 0 {name=S1 only_toplevel=false value=".tran 0.01n 300n
.save all"}
C {sky130_fd_pr/corner.sym} 18565 -7205 0 0 {name=CORNER only_toplevel=true corner=tt}
C {devices/vsource.sym} 17920 -8120 0 0 {name=VDD value=1.8 savecurrent=false}
C {devices/lab_pin.sym} 17920 -8150 0 0 {name=VA2 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 17920 -8090 0 0 {name=l1 lab=GND}
C {sky130_fd_pr/pfet3_01v8.sym} 4180 -13410 0 0 {name=M1
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4180 -13260 0 0 {name=M2
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4060 -13410 0 1 {name=M3
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4060 -13260 0 1 {name=M4
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3860 -13330 3 1 {name=M5
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4350 -13340 3 1 {name=M6
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 4120 -13170 0 0 {name=l3 lab=GND}
C {devices/vdd.sym} 4120 -13490 0 0 {name=l4 lab=VDD}
C {devices/lab_pin.sym} 3780 -13530 0 0 {name=p263 sig_type=std_logic lab=WL}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 3130 -12840 0 0 {name=X33}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 3110 -12210 0 0 {name=X34}
C {sky130_fd_pr/pfet3_01v8.sym} 3340 -12990 0 0 {name=M7
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3340 -12890 0 0 {name=M8
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3340 -12720 0 0 {name=M9
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3340 -12620 0 0 {name=M10
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3340 -12400 0 0 {name=M11
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3340 -12300 0 0 {name=M12
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3340 -12130 0 0 {name=M13
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3340 -12030 0 0 {name=M14
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 3360 -11960 0 0 {name=l5 lab=GND}
C {devices/gnd.sym} 3360 -12550 0 0 {name=l9 lab=GND}
C {devices/vdd.sym} 3360 -13060 0 0 {name=l11 lab=VDD}
C {devices/vdd.sym} 3360 -12450 0 0 {name=l12 lab=VDD}
C {devices/lab_pin.sym} 2960 -12840 0 0 {name=p266 sig_type=std_logic lab=we}
C {sky130_fd_pr/pfet3_01v8.sym} 2830 -13400 3 0 {name=M15
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 2930 -13300 0 0 {name=M16
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 2830 -13220 3 1 {name=M17
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 2760 -13120 3 0 {name=l13 lab=VDD}
C {devices/lab_pin.sym} 2910 -13130 3 0 {name=p268 sig_type=std_logic lab=p_b}
C {sky130_fd_pr/pfet3_01v8.sym} 4290 -12940 0 0 {name=M18
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4190 -12840 1 0 {name=M19
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4110 -12940 0 1 {name=M20
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 4010 -13010 0 0 {name=l14 lab=VDD}
C {devices/lab_pin.sym} 4020 -12860 0 0 {name=p269 sig_type=std_logic lab=p_b}
C {devices/lab_pin.sym} 3840 -12690 0 0 {name=p270 sig_type=std_logic lab=rd}
C {sky130_fd_pr/pfet3_01v8.sym} 4330 -12670 0 1 {name=M21
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4110 -12680 0 1 {name=M22
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4070 -12520 0 0 {name=M23
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4290 -12510 0 0 {name=M24
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4160 -12370 0 0 {name=M25
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 4060 -12370 0 0 {name=l15 lab=VDD}
C {devices/vdd.sym} 4270 -12720 0 0 {name=l16 lab=VDD}
C {devices/gnd.sym} 4180 -12310 0 0 {name=l17 lab=GND
value="pulse(0 1.8 1ns 1ns 1ns 4ns 10ns)"}
C {sky130_fd_pr/pfet3_01v8.sym} 4540 -12610 3 1 {name=M26
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3840 -12620 3 1 {name=M27
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 4540 -12670 0 0 {name=p271 sig_type=std_logic lab=rd}
C {sky130_fd_pr/pfet3_01v8.sym} 6500 -13390 0 0 {name=M28
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 6500 -13240 0 0 {name=M29
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 6380 -13390 0 1 {name=M30
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 6380 -13240 0 1 {name=M31
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 6180 -13310 3 1 {name=M32
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 6670 -13320 3 1 {name=M33
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 6440 -13150 0 0 {name=l6 lab=GND}
C {devices/vdd.sym} 6440 -13470 0 0 {name=l7 lab=VDD}
C {devices/lab_pin.sym} 6100 -13510 0 0 {name=p276 sig_type=std_logic lab=WL}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 5450 -12820 0 0 {name=X35}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 5430 -12190 0 0 {name=X36}
C {sky130_fd_pr/pfet3_01v8.sym} 5660 -12970 0 0 {name=M34
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 5660 -12870 0 0 {name=M35
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 5660 -12700 0 0 {name=M36
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 5660 -12600 0 0 {name=M37
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 5660 -12380 0 0 {name=M38
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 5660 -12280 0 0 {name=M39
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 5660 -12110 0 0 {name=M40
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 5660 -12010 0 0 {name=M41
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 5680 -11940 0 0 {name=l8 lab=GND}
C {devices/gnd.sym} 5680 -12530 0 0 {name=l10 lab=GND}
C {devices/vdd.sym} 5680 -13040 0 0 {name=l18 lab=VDD}
C {devices/vdd.sym} 5680 -12430 0 0 {name=l19 lab=VDD}
C {devices/lab_pin.sym} 5280 -12820 0 0 {name=p279 sig_type=std_logic lab=we}
C {sky130_fd_pr/pfet3_01v8.sym} 5150 -13380 3 0 {name=M42
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 5250 -13280 0 0 {name=M43
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 5150 -13200 3 1 {name=M44
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 5080 -13100 3 0 {name=l20 lab=VDD}
C {devices/lab_pin.sym} 5230 -13110 3 0 {name=p281 sig_type=std_logic lab=p_b}
C {sky130_fd_pr/pfet3_01v8.sym} 6610 -12920 0 0 {name=M45
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 6510 -12820 1 0 {name=M46
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 6430 -12920 0 1 {name=M47
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 6330 -12990 0 0 {name=l21 lab=VDD}
C {devices/lab_pin.sym} 6340 -12840 0 0 {name=p282 sig_type=std_logic lab=p_b}
C {sky130_fd_pr/pfet3_01v8.sym} 6650 -12650 0 1 {name=M48
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 6430 -12660 0 1 {name=M49
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 6390 -12500 0 0 {name=M50
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 6610 -12490 0 0 {name=M51
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 6480 -12350 0 0 {name=M52
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 6380 -12350 0 0 {name=l22 lab=VDD}
C {devices/vdd.sym} 6590 -12700 0 0 {name=l23 lab=VDD}
C {devices/gnd.sym} 6500 -12290 0 0 {name=l24 lab=GND
value="pulse(0 1.8 1ns 1ns 1ns 4ns 10ns)"}
C {sky130_fd_pr/pfet3_01v8.sym} 6860 -12590 3 1 {name=M53
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 6160 -12600 3 1 {name=M54
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 6860 -12650 0 0 {name=p284 sig_type=std_logic lab=rd}
C {sky130_fd_pr/pfet3_01v8.sym} 8650 -13380 0 0 {name=M55
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 8650 -13230 0 0 {name=M56
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 8530 -13380 0 1 {name=M57
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 8530 -13230 0 1 {name=M58
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 8330 -13300 3 1 {name=M59
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 8820 -13310 3 1 {name=M60
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 8590 -13140 0 0 {name=l25 lab=GND}
C {devices/vdd.sym} 8590 -13460 0 0 {name=l26 lab=VDD}
C {devices/lab_pin.sym} 8250 -13500 0 0 {name=p289 sig_type=std_logic lab=WL}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 7600 -12810 0 0 {name=X37}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 7580 -12180 0 0 {name=X38}
C {sky130_fd_pr/pfet3_01v8.sym} 7810 -12960 0 0 {name=M61
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 7810 -12860 0 0 {name=M62
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 7810 -12690 0 0 {name=M63
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 7810 -12590 0 0 {name=M64
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 7810 -12370 0 0 {name=M65
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 7810 -12270 0 0 {name=M66
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 7810 -12100 0 0 {name=M67
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 7810 -12000 0 0 {name=M68
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 7830 -11930 0 0 {name=l27 lab=GND}
C {devices/gnd.sym} 7830 -12520 0 0 {name=l28 lab=GND}
C {devices/vdd.sym} 7830 -13030 0 0 {name=l29 lab=VDD}
C {devices/vdd.sym} 7830 -12420 0 0 {name=l30 lab=VDD}
C {devices/lab_pin.sym} 7430 -12810 0 0 {name=p292 sig_type=std_logic lab=we}
C {sky130_fd_pr/pfet3_01v8.sym} 7300 -13370 3 0 {name=M69
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 7400 -13270 0 0 {name=M70
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 7300 -13190 3 1 {name=M71
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 7230 -13090 3 0 {name=l31 lab=VDD}
C {devices/lab_pin.sym} 7380 -13100 3 0 {name=p294 sig_type=std_logic lab=p_b}
C {sky130_fd_pr/pfet3_01v8.sym} 8760 -12910 0 0 {name=M72
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 8660 -12810 1 0 {name=M73
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 8580 -12910 0 1 {name=M74
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 8480 -12980 0 0 {name=l32 lab=VDD}
C {devices/lab_pin.sym} 8490 -12830 0 0 {name=p295 sig_type=std_logic lab=p_b}
C {devices/lab_pin.sym} 8310 -12660 0 0 {name=p296 sig_type=std_logic lab=rd}
C {sky130_fd_pr/pfet3_01v8.sym} 8800 -12640 0 1 {name=M75
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 8580 -12650 0 1 {name=M76
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 8540 -12490 0 0 {name=M77
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 8760 -12480 0 0 {name=M78
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 8630 -12340 0 0 {name=M79
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 8530 -12340 0 0 {name=l33 lab=VDD}
C {devices/vdd.sym} 8740 -12690 0 0 {name=l34 lab=VDD}
C {devices/gnd.sym} 8650 -12280 0 0 {name=l35 lab=GND
value="pulse(0 1.8 1ns 1ns 1ns 4ns 10ns)"}
C {sky130_fd_pr/pfet3_01v8.sym} 9010 -12580 3 1 {name=M80
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 8310 -12590 3 1 {name=M81
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 9010 -12640 0 0 {name=p297 sig_type=std_logic lab=rd}
C {sky130_fd_pr/pfet3_01v8.sym} 10780 -13380 0 0 {name=M82
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 10780 -13230 0 0 {name=M83
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 10660 -13380 0 1 {name=M84
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 10660 -13230 0 1 {name=M85
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 10460 -13300 3 1 {name=M86
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 10950 -13310 3 1 {name=M87
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 10720 -13140 0 0 {name=l36 lab=GND}
C {devices/vdd.sym} 10720 -13460 0 0 {name=l37 lab=VDD}
C {devices/lab_pin.sym} 10380 -13500 0 0 {name=p302 sig_type=std_logic lab=WL}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 9730 -12810 0 0 {name=X39}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 9710 -12180 0 0 {name=X40}
C {sky130_fd_pr/pfet3_01v8.sym} 9940 -12960 0 0 {name=M88
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 9940 -12860 0 0 {name=M89
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 9940 -12690 0 0 {name=M90
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 9940 -12590 0 0 {name=M91
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 9940 -12370 0 0 {name=M92
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 9940 -12270 0 0 {name=M93
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 9940 -12100 0 0 {name=M94
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 9940 -12000 0 0 {name=M95
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 9960 -11930 0 0 {name=l38 lab=GND}
C {devices/gnd.sym} 9960 -12520 0 0 {name=l39 lab=GND}
C {devices/vdd.sym} 9960 -13030 0 0 {name=l40 lab=VDD}
C {devices/vdd.sym} 9960 -12420 0 0 {name=l41 lab=VDD}
C {devices/lab_pin.sym} 9560 -12810 0 0 {name=p305 sig_type=std_logic lab=we}
C {sky130_fd_pr/pfet3_01v8.sym} 9430 -13370 3 0 {name=M96
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 9530 -13270 0 0 {name=M97
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 9430 -13190 3 1 {name=M98
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 9360 -13090 3 0 {name=l42 lab=VDD}
C {devices/lab_pin.sym} 9510 -13100 3 0 {name=p307 sig_type=std_logic lab=p_b}
C {sky130_fd_pr/pfet3_01v8.sym} 10890 -12910 0 0 {name=M99
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 10790 -12810 1 0 {name=M100
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 10710 -12910 0 1 {name=M101
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 10610 -12980 0 0 {name=l43 lab=VDD}
C {devices/lab_pin.sym} 10620 -12830 0 0 {name=p308 sig_type=std_logic lab=p_b}
C {devices/lab_pin.sym} 10440 -12660 0 0 {name=p309 sig_type=std_logic lab=rd}
C {sky130_fd_pr/pfet3_01v8.sym} 10930 -12640 0 1 {name=M102
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 10710 -12650 0 1 {name=M103
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 10670 -12490 0 0 {name=M104
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 10890 -12480 0 0 {name=M105
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 10760 -12340 0 0 {name=M106
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 10660 -12340 0 0 {name=l44 lab=VDD}
C {devices/vdd.sym} 10870 -12690 0 0 {name=l45 lab=VDD}
C {devices/gnd.sym} 10780 -12280 0 0 {name=l46 lab=GND
value="pulse(0 1.8 1ns 1ns 1ns 4ns 10ns)"}
C {sky130_fd_pr/pfet3_01v8.sym} 11140 -12580 3 1 {name=M107
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 10440 -12590 3 1 {name=M108
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 11140 -12640 0 0 {name=p310 sig_type=std_logic lab=rd}
C {sky130_fd_pr/pfet3_01v8.sym} 13100 -13360 0 0 {name=M109
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 13100 -13210 0 0 {name=M110
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 12980 -13360 0 1 {name=M111
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 12980 -13210 0 1 {name=M112
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 12780 -13280 3 1 {name=M113
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 13270 -13290 3 1 {name=M114
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 13040 -13120 0 0 {name=l47 lab=GND}
C {devices/vdd.sym} 13040 -13440 0 0 {name=l48 lab=VDD}
C {devices/lab_pin.sym} 12700 -13480 0 0 {name=p315 sig_type=std_logic lab=WL}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 12050 -12790 0 0 {name=X41}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 12030 -12160 0 0 {name=X42}
C {sky130_fd_pr/pfet3_01v8.sym} 12260 -12940 0 0 {name=M115
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 12260 -12840 0 0 {name=M116
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 12260 -12670 0 0 {name=M117
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 12260 -12570 0 0 {name=M118
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 12260 -12350 0 0 {name=M119
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 12260 -12250 0 0 {name=M120
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 12260 -12080 0 0 {name=M121
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 12260 -11980 0 0 {name=M122
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 12280 -11910 0 0 {name=l49 lab=GND}
C {devices/gnd.sym} 12280 -12500 0 0 {name=l50 lab=GND}
C {devices/vdd.sym} 12280 -13010 0 0 {name=l51 lab=VDD}
C {devices/vdd.sym} 12280 -12400 0 0 {name=l52 lab=VDD}
C {devices/lab_pin.sym} 11880 -12790 0 0 {name=p318 sig_type=std_logic lab=we}
C {sky130_fd_pr/pfet3_01v8.sym} 11750 -13350 3 0 {name=M123
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 11850 -13250 0 0 {name=M124
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 11750 -13170 3 1 {name=M125
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 11680 -13070 3 0 {name=l53 lab=VDD}
C {devices/lab_pin.sym} 11830 -13080 3 0 {name=p320 sig_type=std_logic lab=p_b}
C {sky130_fd_pr/pfet3_01v8.sym} 13210 -12890 0 0 {name=M126
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 13110 -12790 1 0 {name=M127
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 13030 -12890 0 1 {name=M128
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 12930 -12960 0 0 {name=l54 lab=VDD}
C {devices/lab_pin.sym} 12940 -12810 0 0 {name=p321 sig_type=std_logic lab=p_b}
C {devices/lab_pin.sym} 12760 -12640 0 0 {name=p322 sig_type=std_logic lab=rd}
C {sky130_fd_pr/pfet3_01v8.sym} 13250 -12620 0 1 {name=M129
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 13030 -12630 0 1 {name=M130
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 12990 -12470 0 0 {name=M131
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 13210 -12460 0 0 {name=M132
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 13080 -12320 0 0 {name=M133
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 12980 -12320 0 0 {name=l55 lab=VDD}
C {devices/vdd.sym} 13190 -12670 0 0 {name=l56 lab=VDD}
C {devices/gnd.sym} 13100 -12260 0 0 {name=l57 lab=GND
value="pulse(0 1.8 1ns 1ns 1ns 4ns 10ns)"}
C {sky130_fd_pr/pfet3_01v8.sym} 13460 -12560 3 1 {name=M134
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 12760 -12570 3 1 {name=M135
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 13460 -12620 0 0 {name=p323 sig_type=std_logic lab=rd}
C {sky130_fd_pr/pfet3_01v8.sym} 15250 -13350 0 0 {name=M136
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 15250 -13200 0 0 {name=M137
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 15130 -13350 0 1 {name=M138
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 15130 -13200 0 1 {name=M139
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 14930 -13270 3 1 {name=M140
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 15420 -13280 3 1 {name=M141
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 15190 -13110 0 0 {name=l58 lab=GND}
C {devices/vdd.sym} 15190 -13430 0 0 {name=l59 lab=VDD}
C {devices/ipin.sym} 14850 -13470 0 0 {name=p328 sig_type=std_logic lab=WL}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 14200 -12780 0 0 {name=X43}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 14180 -12150 0 0 {name=X44}
C {sky130_fd_pr/pfet3_01v8.sym} 14410 -12930 0 0 {name=M142
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 14410 -12830 0 0 {name=M143
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 14410 -12660 0 0 {name=M144
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 14410 -12560 0 0 {name=M145
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 14410 -12340 0 0 {name=M146
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 14410 -12240 0 0 {name=M147
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 14410 -12070 0 0 {name=M148
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 14410 -11970 0 0 {name=M149
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 14430 -11900 0 0 {name=l60 lab=GND}
C {devices/gnd.sym} 14430 -12490 0 0 {name=l61 lab=GND}
C {devices/vdd.sym} 14430 -13000 0 0 {name=l62 lab=VDD}
C {devices/vdd.sym} 14430 -12390 0 0 {name=l63 lab=VDD}
C {devices/ipin.sym} 14030 -12780 0 0 {name=p331 sig_type=std_logic lab=we}
C {sky130_fd_pr/pfet3_01v8.sym} 13900 -13340 3 0 {name=M150
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 14000 -13240 0 0 {name=M151
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 13900 -13160 3 1 {name=M152
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 13830 -13060 3 0 {name=l64 lab=VDD}
C {devices/ipin.sym} 13980 -13070 3 0 {name=p333 sig_type=std_logic lab=p_b}
C {sky130_fd_pr/pfet3_01v8.sym} 15360 -12880 0 0 {name=M153
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 15260 -12780 1 0 {name=M154
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 15180 -12880 0 1 {name=M155
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 15080 -12950 0 0 {name=l84 lab=VDD}
C {devices/lab_pin.sym} 15090 -12800 0 0 {name=p334 sig_type=std_logic lab=p_b}
C {devices/ipin.sym} 14910 -12630 0 0 {name=p335 sig_type=std_logic lab=rd}
C {sky130_fd_pr/pfet3_01v8.sym} 15400 -12610 0 1 {name=M156
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 15180 -12620 0 1 {name=M157
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 15140 -12460 0 0 {name=M158
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 15360 -12450 0 0 {name=M159
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 15230 -12310 0 0 {name=M160
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 15130 -12310 0 0 {name=l86 lab=VDD}
C {devices/vdd.sym} 15340 -12660 0 0 {name=l87 lab=VDD}
C {devices/gnd.sym} 15250 -12250 0 0 {name=l88 lab=GND
value="pulse(0 1.8 1ns 1ns 1ns 4ns 10ns)"}
C {sky130_fd_pr/pfet3_01v8.sym} 15610 -12550 3 1 {name=M161
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 14910 -12560 3 1 {name=M162
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 15610 -12610 0 0 {name=p336 sig_type=std_logic lab=rd}
C {devices/lab_pin.sym} 2960 -12210 0 0 {name=p341 sig_type=std_logic lab=d0}
C {devices/lab_pin.sym} 5280 -12190 0 0 {name=p267 sig_type=std_logic lab=d1}
C {devices/lab_pin.sym} 7430 -12180 0 0 {name=p280 sig_type=std_logic lab=d2}
C {devices/lab_pin.sym} 9560 -12180 0 0 {name=p293 sig_type=std_logic lab=d3}
C {devices/lab_pin.sym} 11880 -12160 0 0 {name=p225 sig_type=std_logic lab=d4}
C {devices/lab_pin.sym} 14030 -12150 0 0 {name=p226 sig_type=std_logic lab=d5}
C {devices/lab_pin.sym} 6160 -12670 0 0 {name=p1 sig_type=std_logic lab=rd}
C {sky130_fd_pr/pfet3_01v8.sym} 4520 -11170 0 0 {name=M163
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4520 -11020 0 0 {name=M164
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4400 -11170 0 1 {name=M165
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4400 -11020 0 1 {name=M166
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4200 -11090 3 1 {name=M167
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4690 -11100 3 1 {name=M168
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 4460 -10930 0 0 {name=l2 lab=GND}
C {devices/vdd.sym} 4460 -11250 0 0 {name=l65 lab=VDD}
C {devices/lab_pin.sym} 4120 -11290 0 0 {name=p74 sig_type=std_logic lab=WL}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 3470 -10600 0 0 {name=X1}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 3450 -9970 0 0 {name=X2}
C {sky130_fd_pr/pfet3_01v8.sym} 3680 -10750 0 0 {name=M169
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3680 -10650 0 0 {name=M170
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3680 -10480 0 0 {name=M171
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3680 -10380 0 0 {name=M172
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3680 -10160 0 0 {name=M173
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3680 -10060 0 0 {name=M174
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3680 -9890 0 0 {name=M175
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3680 -9790 0 0 {name=M176
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 3700 -9720 0 0 {name=l66 lab=GND}
C {devices/gnd.sym} 3700 -10310 0 0 {name=l67 lab=GND}
C {devices/vdd.sym} 3700 -10820 0 0 {name=l68 lab=VDD}
C {devices/vdd.sym} 3700 -10210 0 0 {name=l69 lab=VDD}
C {devices/lab_pin.sym} 3300 -10600 0 0 {name=p75 sig_type=std_logic lab=we}
C {sky130_fd_pr/pfet3_01v8.sym} 3170 -11160 3 0 {name=M177
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3270 -11060 0 0 {name=M178
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3170 -10980 3 1 {name=M179
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 3100 -10880 3 0 {name=l70 lab=VDD}
C {devices/lab_pin.sym} 3250 -10890 3 0 {name=p76 sig_type=std_logic lab=p_b}
C {sky130_fd_pr/pfet3_01v8.sym} 4630 -10700 0 0 {name=M180
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4530 -10600 1 0 {name=M181
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4450 -10700 0 1 {name=M182
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 4350 -10770 0 0 {name=l71 lab=VDD}
C {devices/lab_pin.sym} 4360 -10620 0 0 {name=p77 sig_type=std_logic lab=p_b}
C {devices/lab_pin.sym} 4180 -10450 0 0 {name=p78 sig_type=std_logic lab=rd}
C {sky130_fd_pr/pfet3_01v8.sym} 4670 -10430 0 1 {name=M183
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4450 -10440 0 1 {name=M184
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4410 -10280 0 0 {name=M185
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4630 -10270 0 0 {name=M186
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4500 -10130 0 0 {name=M187
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 4400 -10130 0 0 {name=l72 lab=VDD}
C {devices/vdd.sym} 4610 -10480 0 0 {name=l73 lab=VDD}
C {devices/gnd.sym} 4520 -10070 0 0 {name=l74 lab=GND
value="pulse(0 1.8 1ns 1ns 1ns 4ns 10ns)"}
C {sky130_fd_pr/pfet3_01v8.sym} 4880 -10370 3 1 {name=M188
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4180 -10380 3 1 {name=M189
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 4880 -10430 0 0 {name=p79 sig_type=std_logic lab=rd}
C {sky130_fd_pr/pfet3_01v8.sym} 6840 -11150 0 0 {name=M190
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 6840 -11000 0 0 {name=M191
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 6720 -11150 0 1 {name=M192
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 6720 -11000 0 1 {name=M193
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 6520 -11070 3 1 {name=M194
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 7010 -11080 3 1 {name=M195
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 6780 -10910 0 0 {name=l75 lab=GND}
C {devices/vdd.sym} 6780 -11230 0 0 {name=l76 lab=VDD}
C {devices/lab_pin.sym} 6440 -11270 0 0 {name=p80 sig_type=std_logic lab=WL}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 5790 -10580 0 0 {name=X3}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 5770 -9950 0 0 {name=X4}
C {sky130_fd_pr/pfet3_01v8.sym} 6000 -10730 0 0 {name=M196
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 6000 -10630 0 0 {name=M197
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 6000 -10460 0 0 {name=M198
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 6000 -10360 0 0 {name=M199
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 6000 -10140 0 0 {name=M200
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 6000 -10040 0 0 {name=M201
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 6000 -9870 0 0 {name=M202
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 6000 -9770 0 0 {name=M203
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 6020 -9700 0 0 {name=l77 lab=GND}
C {devices/gnd.sym} 6020 -10290 0 0 {name=l78 lab=GND}
C {devices/vdd.sym} 6020 -10800 0 0 {name=l79 lab=VDD}
C {devices/vdd.sym} 6020 -10190 0 0 {name=l80 lab=VDD}
C {devices/lab_pin.sym} 5620 -10580 0 0 {name=p81 sig_type=std_logic lab=we}
C {sky130_fd_pr/pfet3_01v8.sym} 5490 -11140 3 0 {name=M204
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 5590 -11040 0 0 {name=M205
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 5490 -10960 3 1 {name=M206
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 5420 -10860 3 0 {name=l89 lab=VDD}
C {devices/lab_pin.sym} 5570 -10870 3 0 {name=p82 sig_type=std_logic lab=p_b}
C {sky130_fd_pr/pfet3_01v8.sym} 6950 -10680 0 0 {name=M207
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 6850 -10580 1 0 {name=M208
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 6770 -10680 0 1 {name=M209
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 6670 -10750 0 0 {name=l90 lab=VDD}
C {devices/lab_pin.sym} 6680 -10600 0 0 {name=p83 sig_type=std_logic lab=p_b}
C {sky130_fd_pr/pfet3_01v8.sym} 6990 -10410 0 1 {name=M210
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 6770 -10420 0 1 {name=M211
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 6730 -10260 0 0 {name=M212
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 6950 -10250 0 0 {name=M213
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 6820 -10110 0 0 {name=M214
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 6720 -10110 0 0 {name=l91 lab=VDD}
C {devices/vdd.sym} 6930 -10460 0 0 {name=l92 lab=VDD}
C {devices/gnd.sym} 6840 -10050 0 0 {name=l93 lab=GND
value="pulse(0 1.8 1ns 1ns 1ns 4ns 10ns)"}
C {sky130_fd_pr/pfet3_01v8.sym} 7200 -10350 3 1 {name=M215
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 6500 -10360 3 1 {name=M216
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 7200 -10410 0 0 {name=p84 sig_type=std_logic lab=rd}
C {sky130_fd_pr/pfet3_01v8.sym} 8990 -11140 0 0 {name=M217
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 8990 -10990 0 0 {name=M218
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 8870 -11140 0 1 {name=M219
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 8870 -10990 0 1 {name=M220
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 8670 -11060 3 1 {name=M221
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 9160 -11070 3 1 {name=M222
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 8930 -10900 0 0 {name=l94 lab=GND}
C {devices/vdd.sym} 8930 -11220 0 0 {name=l95 lab=VDD}
C {devices/lab_pin.sym} 8590 -11260 0 0 {name=p85 sig_type=std_logic lab=WL}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 7940 -10570 0 0 {name=X5}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 7920 -9940 0 0 {name=X6}
C {sky130_fd_pr/pfet3_01v8.sym} 8150 -10720 0 0 {name=M223
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 8150 -10620 0 0 {name=M224
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 8150 -10450 0 0 {name=M225
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 8150 -10350 0 0 {name=M226
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 8150 -10130 0 0 {name=M227
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 8150 -10030 0 0 {name=M228
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 8150 -9860 0 0 {name=M229
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 8150 -9760 0 0 {name=M230
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 8170 -9690 0 0 {name=l96 lab=GND}
C {devices/gnd.sym} 8170 -10280 0 0 {name=l97 lab=GND}
C {devices/vdd.sym} 8170 -10790 0 0 {name=l98 lab=VDD}
C {devices/vdd.sym} 8170 -10180 0 0 {name=l99 lab=VDD}
C {devices/lab_pin.sym} 7770 -10570 0 0 {name=p86 sig_type=std_logic lab=we}
C {sky130_fd_pr/pfet3_01v8.sym} 7640 -11130 3 0 {name=M231
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 7740 -11030 0 0 {name=M232
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 7640 -10950 3 1 {name=M233
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 7570 -10850 3 0 {name=l100 lab=VDD}
C {devices/lab_pin.sym} 7720 -10860 3 0 {name=p87 sig_type=std_logic lab=p_b}
C {sky130_fd_pr/pfet3_01v8.sym} 9100 -10670 0 0 {name=M234
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 9000 -10570 1 0 {name=M235
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 8920 -10670 0 1 {name=M236
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 8820 -10740 0 0 {name=l101 lab=VDD}
C {devices/lab_pin.sym} 8830 -10590 0 0 {name=p88 sig_type=std_logic lab=p_b}
C {devices/lab_pin.sym} 8650 -10420 0 0 {name=p89 sig_type=std_logic lab=rd}
C {sky130_fd_pr/pfet3_01v8.sym} 9140 -10400 0 1 {name=M237
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 8920 -10410 0 1 {name=M238
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 8880 -10250 0 0 {name=M239
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 9100 -10240 0 0 {name=M240
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 8970 -10100 0 0 {name=M241
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 8870 -10100 0 0 {name=l102 lab=VDD}
C {devices/vdd.sym} 9080 -10450 0 0 {name=l103 lab=VDD}
C {devices/gnd.sym} 8990 -10040 0 0 {name=l104 lab=GND
value="pulse(0 1.8 1ns 1ns 1ns 4ns 10ns)"}
C {sky130_fd_pr/pfet3_01v8.sym} 9350 -10340 3 1 {name=M242
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 8650 -10350 3 1 {name=M243
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 9350 -10400 0 0 {name=p90 sig_type=std_logic lab=rd}
C {sky130_fd_pr/pfet3_01v8.sym} 11120 -11140 0 0 {name=M244
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 11120 -10990 0 0 {name=M245
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 11000 -11140 0 1 {name=M246
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 11000 -10990 0 1 {name=M247
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 10800 -11060 3 1 {name=M248
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 11290 -11070 3 1 {name=M249
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 11060 -10900 0 0 {name=l105 lab=GND}
C {devices/vdd.sym} 11060 -11220 0 0 {name=l106 lab=VDD}
C {devices/lab_pin.sym} 10720 -11260 0 0 {name=p91 sig_type=std_logic lab=WL}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 10070 -10570 0 0 {name=X7}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 10050 -9940 0 0 {name=X8}
C {sky130_fd_pr/pfet3_01v8.sym} 10280 -10720 0 0 {name=M250
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 10280 -10620 0 0 {name=M251
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 10280 -10450 0 0 {name=M252
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 10280 -10350 0 0 {name=M253
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 10280 -10130 0 0 {name=M254
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 10280 -10030 0 0 {name=M255
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 10280 -9860 0 0 {name=M256
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 10280 -9760 0 0 {name=M257
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 10300 -9690 0 0 {name=l111 lab=GND}
C {devices/gnd.sym} 10300 -10280 0 0 {name=l112 lab=GND}
C {devices/vdd.sym} 10300 -10790 0 0 {name=l113 lab=VDD}
C {devices/vdd.sym} 10300 -10180 0 0 {name=l114 lab=VDD}
C {devices/lab_pin.sym} 9900 -10570 0 0 {name=p92 sig_type=std_logic lab=we}
C {sky130_fd_pr/pfet3_01v8.sym} 9770 -11130 3 0 {name=M258
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 9870 -11030 0 0 {name=M259
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 9770 -10950 3 1 {name=M260
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 9700 -10850 3 0 {name=l115 lab=VDD}
C {devices/lab_pin.sym} 9850 -10860 3 0 {name=p93 sig_type=std_logic lab=p_b}
C {sky130_fd_pr/pfet3_01v8.sym} 11230 -10670 0 0 {name=M261
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 11130 -10570 1 0 {name=M262
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 11050 -10670 0 1 {name=M263
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 10950 -10740 0 0 {name=l116 lab=VDD}
C {devices/lab_pin.sym} 10960 -10590 0 0 {name=p94 sig_type=std_logic lab=p_b}
C {devices/lab_pin.sym} 10780 -10420 0 0 {name=p95 sig_type=std_logic lab=rd}
C {sky130_fd_pr/pfet3_01v8.sym} 11270 -10400 0 1 {name=M264
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 11050 -10410 0 1 {name=M265
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 11010 -10250 0 0 {name=M266
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 11230 -10240 0 0 {name=M267
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 11100 -10100 0 0 {name=M268
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 11000 -10100 0 0 {name=l117 lab=VDD}
C {devices/vdd.sym} 11210 -10450 0 0 {name=l118 lab=VDD}
C {devices/gnd.sym} 11120 -10040 0 0 {name=l119 lab=GND
value="pulse(0 1.8 1ns 1ns 1ns 4ns 10ns)"}
C {sky130_fd_pr/pfet3_01v8.sym} 11480 -10340 3 1 {name=M269
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 10780 -10350 3 1 {name=M270
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 11480 -10400 0 0 {name=p96 sig_type=std_logic lab=rd}
C {sky130_fd_pr/pfet3_01v8.sym} 13440 -11120 0 0 {name=M271
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 13440 -10970 0 0 {name=M272
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 13320 -11120 0 1 {name=M273
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 13320 -10970 0 1 {name=M274
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 13120 -11040 3 1 {name=M275
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 13610 -11050 3 1 {name=M276
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 13380 -10880 0 0 {name=l120 lab=GND}
C {devices/vdd.sym} 13380 -11200 0 0 {name=l123 lab=VDD}
C {devices/lab_pin.sym} 13040 -11240 0 0 {name=p97 sig_type=std_logic lab=WL}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 12390 -10550 0 0 {name=X9}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 12370 -9920 0 0 {name=X10}
C {sky130_fd_pr/pfet3_01v8.sym} 12600 -10700 0 0 {name=M277
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 12600 -10600 0 0 {name=M278
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 12600 -10430 0 0 {name=M279
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 12600 -10330 0 0 {name=M280
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 12600 -10110 0 0 {name=M281
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 12600 -10010 0 0 {name=M282
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 12600 -9840 0 0 {name=M283
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 12600 -9740 0 0 {name=M284
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 12620 -9670 0 0 {name=l124 lab=GND}
C {devices/gnd.sym} 12620 -10260 0 0 {name=l125 lab=GND}
C {devices/vdd.sym} 12620 -10770 0 0 {name=l126 lab=VDD}
C {devices/vdd.sym} 12620 -10160 0 0 {name=l127 lab=VDD}
C {devices/lab_pin.sym} 12220 -10550 0 0 {name=p98 sig_type=std_logic lab=we}
C {sky130_fd_pr/pfet3_01v8.sym} 12090 -11110 3 0 {name=M285
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 12190 -11010 0 0 {name=M286
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 12090 -10930 3 1 {name=M287
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 12020 -10830 3 0 {name=l128 lab=VDD}
C {devices/lab_pin.sym} 12170 -10840 3 0 {name=p99 sig_type=std_logic lab=p_b}
C {sky130_fd_pr/pfet3_01v8.sym} 13550 -10650 0 0 {name=M288
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 13450 -10550 1 0 {name=M289
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 13370 -10650 0 1 {name=M290
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 13270 -10720 0 0 {name=l129 lab=VDD}
C {devices/lab_pin.sym} 13280 -10570 0 0 {name=p100 sig_type=std_logic lab=p_b}
C {devices/lab_pin.sym} 13100 -10400 0 0 {name=p101 sig_type=std_logic lab=rd}
C {sky130_fd_pr/pfet3_01v8.sym} 13590 -10380 0 1 {name=M291
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 13370 -10390 0 1 {name=M292
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 13330 -10230 0 0 {name=M293
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 13550 -10220 0 0 {name=M294
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 13420 -10080 0 0 {name=M295
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 13320 -10080 0 0 {name=l130 lab=VDD}
C {devices/vdd.sym} 13530 -10430 0 0 {name=l131 lab=VDD}
C {devices/gnd.sym} 13440 -10020 0 0 {name=l132 lab=GND
value="pulse(0 1.8 1ns 1ns 1ns 4ns 10ns)"}
C {sky130_fd_pr/pfet3_01v8.sym} 13800 -10320 3 1 {name=M296
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 13100 -10330 3 1 {name=M297
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 13800 -10380 0 0 {name=p102 sig_type=std_logic lab=rd}
C {sky130_fd_pr/pfet3_01v8.sym} 15590 -11110 0 0 {name=M298
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 15590 -10960 0 0 {name=M299
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 15470 -11110 0 1 {name=M300
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 15470 -10960 0 1 {name=M301
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 15270 -11030 3 1 {name=M302
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 15760 -11040 3 1 {name=M303
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 15530 -10870 0 0 {name=l133 lab=GND}
C {devices/vdd.sym} 15530 -11190 0 0 {name=l134 lab=VDD}
C {devices/lab_pin.sym} 15190 -11230 0 0 {name=p103 sig_type=std_logic lab=WL}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 14540 -10540 0 0 {name=X11}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 14520 -9910 0 0 {name=X12}
C {sky130_fd_pr/pfet3_01v8.sym} 14750 -10690 0 0 {name=M304
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 14750 -10590 0 0 {name=M305
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 14750 -10420 0 0 {name=M306
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 14750 -10320 0 0 {name=M307
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 14750 -10100 0 0 {name=M308
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 14750 -10000 0 0 {name=M309
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 14750 -9830 0 0 {name=M310
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 14750 -9730 0 0 {name=M311
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 14770 -9660 0 0 {name=l135 lab=GND}
C {devices/gnd.sym} 14770 -10250 0 0 {name=l136 lab=GND}
C {devices/vdd.sym} 14770 -10760 0 0 {name=l137 lab=VDD}
C {devices/vdd.sym} 14770 -10150 0 0 {name=l138 lab=VDD}
C {devices/lab_pin.sym} 14370 -10540 0 0 {name=p104 sig_type=std_logic lab=we}
C {sky130_fd_pr/pfet3_01v8.sym} 14240 -11100 3 0 {name=M312
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 14340 -11000 0 0 {name=M313
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 14240 -10920 3 1 {name=M314
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 14170 -10820 3 0 {name=l139 lab=VDD}
C {devices/lab_pin.sym} 14320 -10830 3 0 {name=p105 sig_type=std_logic lab=p_b}
C {sky130_fd_pr/pfet3_01v8.sym} 15700 -10640 0 0 {name=M315
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 15600 -10540 1 0 {name=M316
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 15520 -10640 0 1 {name=M317
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 15420 -10710 0 0 {name=l140 lab=VDD}
C {devices/lab_pin.sym} 15430 -10560 0 0 {name=p106 sig_type=std_logic lab=p_b}
C {devices/lab_pin.sym} 15250 -10390 0 0 {name=p107 sig_type=std_logic lab=rd}
C {sky130_fd_pr/pfet3_01v8.sym} 15740 -10370 0 1 {name=M318
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 15520 -10380 0 1 {name=M319
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 15480 -10220 0 0 {name=M320
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 15700 -10210 0 0 {name=M321
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 15570 -10070 0 0 {name=M322
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 15470 -10070 0 0 {name=l141 lab=VDD}
C {devices/vdd.sym} 15680 -10420 0 0 {name=l142 lab=VDD}
C {devices/gnd.sym} 15590 -10010 0 0 {name=l143 lab=GND
value="pulse(0 1.8 1ns 1ns 1ns 4ns 10ns)"}
C {sky130_fd_pr/pfet3_01v8.sym} 15950 -10310 3 1 {name=M323
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 15250 -10320 3 1 {name=M324
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 15950 -10370 0 0 {name=p108 sig_type=std_logic lab=rd}
C {devices/lab_pin.sym} 3300 -9970 0 0 {name=p109 sig_type=std_logic lab=d6}
C {devices/lab_pin.sym} 5620 -9950 0 0 {name=p110 sig_type=std_logic lab=d7}
C {devices/lab_pin.sym} 7770 -9940 0 0 {name=p111 sig_type=std_logic lab=d8}
C {devices/lab_pin.sym} 9900 -9940 0 0 {name=p112 sig_type=std_logic lab=d9}
C {devices/lab_pin.sym} 12220 -9920 0 0 {name=p113 sig_type=std_logic lab=d10}
C {devices/lab_pin.sym} 14370 -9910 0 0 {name=p114 sig_type=std_logic lab=d11}
C {devices/lab_pin.sym} 6500 -10430 0 0 {name=p115 sig_type=std_logic lab=rd}
C {sky130_fd_pr/pfet3_01v8.sym} 4600 -8910 0 0 {name=M325
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4600 -8760 0 0 {name=M326
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4480 -8910 0 1 {name=M327
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4480 -8760 0 1 {name=M328
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4280 -8830 3 1 {name=M329
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4770 -8840 3 1 {name=M330
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 4540 -8670 0 0 {name=l144 lab=GND}
C {devices/vdd.sym} 4540 -8990 0 0 {name=l145 lab=VDD}
C {devices/lab_pin.sym} 4200 -9030 0 0 {name=p152 sig_type=std_logic lab=WL}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 3550 -8340 0 0 {name=X13}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 3530 -7710 0 0 {name=X14}
C {sky130_fd_pr/pfet3_01v8.sym} 3760 -8490 0 0 {name=M331
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3760 -8390 0 0 {name=M332
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3760 -8220 0 0 {name=M333
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3760 -8120 0 0 {name=M334
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3760 -7900 0 0 {name=M335
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3760 -7800 0 0 {name=M336
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3760 -7630 0 0 {name=M337
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3760 -7530 0 0 {name=M338
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 3780 -7460 0 0 {name=l146 lab=GND}
C {devices/gnd.sym} 3780 -8050 0 0 {name=l147 lab=GND}
C {devices/vdd.sym} 3780 -8560 0 0 {name=l148 lab=VDD}
C {devices/vdd.sym} 3780 -7950 0 0 {name=l149 lab=VDD}
C {devices/lab_pin.sym} 3380 -8340 0 0 {name=p153 sig_type=std_logic lab=we}
C {sky130_fd_pr/pfet3_01v8.sym} 3250 -8900 3 0 {name=M339
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3350 -8800 0 0 {name=M340
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3250 -8720 3 1 {name=M341
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 3180 -8620 3 0 {name=l150 lab=VDD}
C {devices/lab_pin.sym} 3330 -8630 3 0 {name=p154 sig_type=std_logic lab=p_b}
C {sky130_fd_pr/pfet3_01v8.sym} 4710 -8440 0 0 {name=M342
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4610 -8340 1 0 {name=M343
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4530 -8440 0 1 {name=M344
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 4430 -8510 0 0 {name=l151 lab=VDD}
C {devices/lab_pin.sym} 4440 -8360 0 0 {name=p155 sig_type=std_logic lab=p_b}
C {devices/lab_pin.sym} 4260 -8190 0 0 {name=p156 sig_type=std_logic lab=rd}
C {sky130_fd_pr/pfet3_01v8.sym} 4750 -8170 0 1 {name=M345
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4530 -8180 0 1 {name=M346
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4490 -8020 0 0 {name=M347
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4710 -8010 0 0 {name=M348
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4580 -7870 0 0 {name=M349
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 4480 -7870 0 0 {name=l152 lab=VDD}
C {devices/vdd.sym} 4690 -8220 0 0 {name=l153 lab=VDD}
C {devices/gnd.sym} 4600 -7810 0 0 {name=l154 lab=GND
value="pulse(0 1.8 1ns 1ns 1ns 4ns 10ns)"}
C {sky130_fd_pr/pfet3_01v8.sym} 4960 -8110 3 1 {name=M350
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4260 -8120 3 1 {name=M351
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 4960 -8170 0 0 {name=p157 sig_type=std_logic lab=rd}
C {sky130_fd_pr/pfet3_01v8.sym} 6920 -8890 0 0 {name=M352
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 6920 -8740 0 0 {name=M353
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 6800 -8890 0 1 {name=M354
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 6800 -8740 0 1 {name=M355
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 6600 -8810 3 1 {name=M356
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 7090 -8820 3 1 {name=M357
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 6860 -8650 0 0 {name=l155 lab=GND}
C {devices/vdd.sym} 6860 -8970 0 0 {name=l156 lab=VDD}
C {devices/lab_pin.sym} 6520 -9010 0 0 {name=p158 sig_type=std_logic lab=WL}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 5870 -8320 0 0 {name=X15}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 5850 -7690 0 0 {name=X16}
C {sky130_fd_pr/pfet3_01v8.sym} 6080 -8470 0 0 {name=M358
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 6080 -8370 0 0 {name=M359
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 6080 -8200 0 0 {name=M360
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 6080 -8100 0 0 {name=M361
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 6080 -7880 0 0 {name=M362
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 6080 -7780 0 0 {name=M363
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 6080 -7610 0 0 {name=M364
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 6080 -7510 0 0 {name=M365
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 6100 -7440 0 0 {name=l157 lab=GND}
C {devices/gnd.sym} 6100 -8030 0 0 {name=l158 lab=GND}
C {devices/vdd.sym} 6100 -8540 0 0 {name=l159 lab=VDD}
C {devices/vdd.sym} 6100 -7930 0 0 {name=l160 lab=VDD}
C {devices/lab_pin.sym} 5700 -8320 0 0 {name=p159 sig_type=std_logic lab=we}
C {sky130_fd_pr/pfet3_01v8.sym} 5570 -8880 3 0 {name=M366
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 5670 -8780 0 0 {name=M367
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 5570 -8700 3 1 {name=M368
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 5500 -8600 3 0 {name=l161 lab=VDD}
C {devices/lab_pin.sym} 5650 -8610 3 0 {name=p160 sig_type=std_logic lab=p_b}
C {sky130_fd_pr/pfet3_01v8.sym} 7030 -8420 0 0 {name=M369
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 6930 -8320 1 0 {name=M370
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 6850 -8420 0 1 {name=M371
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 6750 -8490 0 0 {name=l162 lab=VDD}
C {devices/lab_pin.sym} 6760 -8340 0 0 {name=p161 sig_type=std_logic lab=p_b}
C {sky130_fd_pr/pfet3_01v8.sym} 7070 -8150 0 1 {name=M372
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 6850 -8160 0 1 {name=M373
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 6810 -8000 0 0 {name=M374
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 7030 -7990 0 0 {name=M375
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 6900 -7850 0 0 {name=M376
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 6800 -7850 0 0 {name=l163 lab=VDD}
C {devices/vdd.sym} 7010 -8200 0 0 {name=l164 lab=VDD}
C {devices/gnd.sym} 6920 -7790 0 0 {name=l165 lab=GND
value="pulse(0 1.8 1ns 1ns 1ns 4ns 10ns)"}
C {sky130_fd_pr/pfet3_01v8.sym} 7280 -8090 3 1 {name=M377
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 6580 -8100 3 1 {name=M378
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 7280 -8150 0 0 {name=p162 sig_type=std_logic lab=rd}
C {sky130_fd_pr/pfet3_01v8.sym} 9070 -8880 0 0 {name=M379
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 9070 -8730 0 0 {name=M380
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 8950 -8880 0 1 {name=M381
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 8950 -8730 0 1 {name=M382
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 8750 -8800 3 1 {name=M383
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 9240 -8810 3 1 {name=M384
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 9010 -8640 0 0 {name=l166 lab=GND}
C {devices/vdd.sym} 9010 -8960 0 0 {name=l167 lab=VDD}
C {devices/lab_pin.sym} 8670 -9000 0 0 {name=p163 sig_type=std_logic lab=WL}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 8020 -8310 0 0 {name=X17}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 8000 -7680 0 0 {name=X18}
C {sky130_fd_pr/pfet3_01v8.sym} 8230 -8460 0 0 {name=M385
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 8230 -8360 0 0 {name=M386
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 8230 -8190 0 0 {name=M387
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 8230 -8090 0 0 {name=M388
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 8230 -7870 0 0 {name=M389
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 8230 -7770 0 0 {name=M390
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 8230 -7600 0 0 {name=M391
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 8230 -7500 0 0 {name=M392
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 8250 -7430 0 0 {name=l168 lab=GND}
C {devices/gnd.sym} 8250 -8020 0 0 {name=l169 lab=GND}
C {devices/vdd.sym} 8250 -8530 0 0 {name=l170 lab=VDD}
C {devices/vdd.sym} 8250 -7920 0 0 {name=l171 lab=VDD}
C {devices/lab_pin.sym} 7850 -8310 0 0 {name=p164 sig_type=std_logic lab=we}
C {sky130_fd_pr/pfet3_01v8.sym} 7720 -8870 3 0 {name=M393
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 7820 -8770 0 0 {name=M394
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 7720 -8690 3 1 {name=M395
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 7650 -8590 3 0 {name=l172 lab=VDD}
C {devices/lab_pin.sym} 7800 -8600 3 0 {name=p165 sig_type=std_logic lab=p_b}
C {sky130_fd_pr/pfet3_01v8.sym} 9180 -8410 0 0 {name=M396
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 9080 -8310 1 0 {name=M397
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 9000 -8410 0 1 {name=M398
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 8900 -8480 0 0 {name=l173 lab=VDD}
C {devices/lab_pin.sym} 8910 -8330 0 0 {name=p166 sig_type=std_logic lab=p_b}
C {devices/lab_pin.sym} 8730 -8160 0 0 {name=p167 sig_type=std_logic lab=rd}
C {sky130_fd_pr/pfet3_01v8.sym} 9220 -8140 0 1 {name=M399
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 9000 -8150 0 1 {name=M400
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 8960 -7990 0 0 {name=M401
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 9180 -7980 0 0 {name=M402
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 9050 -7840 0 0 {name=M403
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 8950 -7840 0 0 {name=l174 lab=VDD}
C {devices/vdd.sym} 9160 -8190 0 0 {name=l175 lab=VDD}
C {devices/gnd.sym} 9070 -7780 0 0 {name=l176 lab=GND
value="pulse(0 1.8 1ns 1ns 1ns 4ns 10ns)"}
C {sky130_fd_pr/pfet3_01v8.sym} 9430 -8080 3 1 {name=M404
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 8730 -8090 3 1 {name=M405
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 9430 -8140 0 0 {name=p168 sig_type=std_logic lab=rd}
C {sky130_fd_pr/pfet3_01v8.sym} 11200 -8880 0 0 {name=M406
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 11200 -8730 0 0 {name=M407
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 11080 -8880 0 1 {name=M408
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 11080 -8730 0 1 {name=M409
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 10880 -8800 3 1 {name=M410
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 11370 -8810 3 1 {name=M411
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 11140 -8640 0 0 {name=l177 lab=GND}
C {devices/vdd.sym} 11140 -8960 0 0 {name=l178 lab=VDD}
C {devices/lab_pin.sym} 10800 -9000 0 0 {name=p169 sig_type=std_logic lab=WL}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 10150 -8310 0 0 {name=X19}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 10130 -7680 0 0 {name=X20}
C {sky130_fd_pr/pfet3_01v8.sym} 10360 -8460 0 0 {name=M412
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 10360 -8360 0 0 {name=M413
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 10360 -8190 0 0 {name=M414
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 10360 -8090 0 0 {name=M415
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 10360 -7870 0 0 {name=M416
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 10360 -7770 0 0 {name=M417
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 10360 -7600 0 0 {name=M418
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 10360 -7500 0 0 {name=M419
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 10380 -7430 0 0 {name=l179 lab=GND}
C {devices/gnd.sym} 10380 -8020 0 0 {name=l180 lab=GND}
C {devices/vdd.sym} 10380 -8530 0 0 {name=l181 lab=VDD}
C {devices/vdd.sym} 10380 -7920 0 0 {name=l182 lab=VDD}
C {devices/lab_pin.sym} 9980 -8310 0 0 {name=p170 sig_type=std_logic lab=we}
C {sky130_fd_pr/pfet3_01v8.sym} 9850 -8870 3 0 {name=M420
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 9950 -8770 0 0 {name=M421
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 9850 -8690 3 1 {name=M422
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 9780 -8590 3 0 {name=l183 lab=VDD}
C {devices/lab_pin.sym} 9930 -8600 3 0 {name=p171 sig_type=std_logic lab=p_b}
C {sky130_fd_pr/pfet3_01v8.sym} 11310 -8410 0 0 {name=M423
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 11210 -8310 1 0 {name=M424
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 11130 -8410 0 1 {name=M425
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 11030 -8480 0 0 {name=l184 lab=VDD}
C {devices/lab_pin.sym} 11040 -8330 0 0 {name=p172 sig_type=std_logic lab=p_b}
C {devices/lab_pin.sym} 10860 -8160 0 0 {name=p173 sig_type=std_logic lab=rd}
C {sky130_fd_pr/pfet3_01v8.sym} 11350 -8140 0 1 {name=M426
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 11130 -8150 0 1 {name=M427
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 11090 -7990 0 0 {name=M428
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 11310 -7980 0 0 {name=M429
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 11180 -7840 0 0 {name=M430
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 11080 -7840 0 0 {name=l185 lab=VDD}
C {devices/vdd.sym} 11290 -8190 0 0 {name=l186 lab=VDD}
C {devices/gnd.sym} 11200 -7780 0 0 {name=l187 lab=GND
value="pulse(0 1.8 1ns 1ns 1ns 4ns 10ns)"}
C {sky130_fd_pr/pfet3_01v8.sym} 11560 -8080 3 1 {name=M431
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 10860 -8090 3 1 {name=M432
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 11560 -8140 0 0 {name=p174 sig_type=std_logic lab=rd}
C {sky130_fd_pr/pfet3_01v8.sym} 13520 -8860 0 0 {name=M433
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 13520 -8710 0 0 {name=M434
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 13400 -8860 0 1 {name=M435
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 13400 -8710 0 1 {name=M436
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 13200 -8780 3 1 {name=M437
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 13690 -8790 3 1 {name=M438
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 13460 -8620 0 0 {name=l188 lab=GND}
C {devices/vdd.sym} 13460 -8940 0 0 {name=l189 lab=VDD}
C {devices/lab_pin.sym} 13120 -8980 0 0 {name=p175 sig_type=std_logic lab=WL}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 12470 -8290 0 0 {name=X21}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 12450 -7660 0 0 {name=X22}
C {sky130_fd_pr/pfet3_01v8.sym} 12680 -8440 0 0 {name=M439
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 12680 -8340 0 0 {name=M440
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 12680 -8170 0 0 {name=M441
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 12680 -8070 0 0 {name=M442
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 12680 -7850 0 0 {name=M443
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 12680 -7750 0 0 {name=M444
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 12680 -7580 0 0 {name=M445
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 12680 -7480 0 0 {name=M446
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 12700 -7410 0 0 {name=l190 lab=GND}
C {devices/gnd.sym} 12700 -8000 0 0 {name=l191 lab=GND}
C {devices/vdd.sym} 12700 -8510 0 0 {name=l192 lab=VDD}
C {devices/vdd.sym} 12700 -7900 0 0 {name=l193 lab=VDD}
C {devices/lab_pin.sym} 12300 -8290 0 0 {name=p176 sig_type=std_logic lab=we}
C {sky130_fd_pr/pfet3_01v8.sym} 12170 -8850 3 0 {name=M447
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 12270 -8750 0 0 {name=M448
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 12170 -8670 3 1 {name=M449
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 12100 -8570 3 0 {name=l194 lab=VDD}
C {devices/lab_pin.sym} 12250 -8580 3 0 {name=p177 sig_type=std_logic lab=p_b}
C {sky130_fd_pr/pfet3_01v8.sym} 13630 -8390 0 0 {name=M450
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 13530 -8290 1 0 {name=M451
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 13450 -8390 0 1 {name=M452
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 13350 -8460 0 0 {name=l195 lab=VDD}
C {devices/lab_pin.sym} 13360 -8310 0 0 {name=p178 sig_type=std_logic lab=p_b}
C {devices/lab_pin.sym} 13180 -8140 0 0 {name=p179 sig_type=std_logic lab=rd}
C {sky130_fd_pr/pfet3_01v8.sym} 13670 -8120 0 1 {name=M453
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 13450 -8130 0 1 {name=M454
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 13410 -7970 0 0 {name=M455
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 13630 -7960 0 0 {name=M456
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 13500 -7820 0 0 {name=M457
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 13400 -7820 0 0 {name=l196 lab=VDD}
C {devices/vdd.sym} 13610 -8170 0 0 {name=l197 lab=VDD}
C {devices/gnd.sym} 13520 -7760 0 0 {name=l198 lab=GND
value="pulse(0 1.8 1ns 1ns 1ns 4ns 10ns)"}
C {sky130_fd_pr/pfet3_01v8.sym} 13880 -8060 3 1 {name=M458
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 13180 -8070 3 1 {name=M459
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 13880 -8120 0 0 {name=p180 sig_type=std_logic lab=rd}
C {sky130_fd_pr/pfet3_01v8.sym} 15670 -8850 0 0 {name=M460
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 15670 -8700 0 0 {name=M461
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 15550 -8850 0 1 {name=M462
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 15550 -8700 0 1 {name=M463
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 15350 -8770 3 1 {name=M464
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 15840 -8780 3 1 {name=M465
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 15610 -8610 0 0 {name=l199 lab=GND}
C {devices/vdd.sym} 15610 -8930 0 0 {name=l200 lab=VDD}
C {devices/lab_pin.sym} 15270 -8970 0 0 {name=p181 sig_type=std_logic lab=WL}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 14620 -8280 0 0 {name=X23}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 14600 -7650 0 0 {name=X24}
C {sky130_fd_pr/pfet3_01v8.sym} 14830 -8430 0 0 {name=M466
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 14830 -8330 0 0 {name=M467
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 14830 -8160 0 0 {name=M468
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 14830 -8060 0 0 {name=M469
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 14830 -7840 0 0 {name=M470
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 14830 -7740 0 0 {name=M471
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 14830 -7570 0 0 {name=M472
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 14830 -7470 0 0 {name=M473
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 14850 -7400 0 0 {name=l201 lab=GND}
C {devices/gnd.sym} 14850 -7990 0 0 {name=l202 lab=GND}
C {devices/vdd.sym} 14850 -8500 0 0 {name=l203 lab=VDD}
C {devices/vdd.sym} 14850 -7890 0 0 {name=l204 lab=VDD}
C {devices/lab_pin.sym} 14450 -8280 0 0 {name=p182 sig_type=std_logic lab=we}
C {sky130_fd_pr/pfet3_01v8.sym} 14320 -8840 3 0 {name=M474
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 14420 -8740 0 0 {name=M475
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 14320 -8660 3 1 {name=M476
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 14250 -8560 3 0 {name=l205 lab=VDD}
C {devices/lab_pin.sym} 14400 -8570 3 0 {name=p183 sig_type=std_logic lab=p_b}
C {sky130_fd_pr/pfet3_01v8.sym} 15780 -8380 0 0 {name=M477
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 15680 -8280 1 0 {name=M478
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 15600 -8380 0 1 {name=M479
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 15500 -8450 0 0 {name=l206 lab=VDD}
C {devices/lab_pin.sym} 15510 -8300 0 0 {name=p184 sig_type=std_logic lab=p_b}
C {devices/lab_pin.sym} 15330 -8130 0 0 {name=p185 sig_type=std_logic lab=rd}
C {sky130_fd_pr/pfet3_01v8.sym} 15820 -8110 0 1 {name=M480
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 15600 -8120 0 1 {name=M481
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 15560 -7960 0 0 {name=M482
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 15780 -7950 0 0 {name=M483
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 15650 -7810 0 0 {name=M484
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 15550 -7810 0 0 {name=l207 lab=VDD}
C {devices/vdd.sym} 15760 -8160 0 0 {name=l208 lab=VDD}
C {devices/gnd.sym} 15670 -7750 0 0 {name=l209 lab=GND
value="pulse(0 1.8 1ns 1ns 1ns 4ns 10ns)"}
C {sky130_fd_pr/pfet3_01v8.sym} 16030 -8050 3 1 {name=M485
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 15330 -8060 3 1 {name=M486
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 16030 -8110 0 0 {name=p186 sig_type=std_logic lab=rd}
C {devices/lab_pin.sym} 3380 -7710 0 0 {name=p187 sig_type=std_logic lab=d12}
C {devices/lab_pin.sym} 5700 -7690 0 0 {name=p188 sig_type=std_logic lab=d13}
C {devices/lab_pin.sym} 7850 -7680 0 0 {name=p189 sig_type=std_logic lab=d14}
C {devices/lab_pin.sym} 9980 -7680 0 0 {name=p190 sig_type=std_logic lab=d15}
C {devices/lab_pin.sym} 12300 -7660 0 0 {name=p191 sig_type=std_logic lab=d16}
C {devices/lab_pin.sym} 14450 -7650 0 0 {name=p192 sig_type=std_logic lab=d17}
C {devices/lab_pin.sym} 6580 -8170 0 0 {name=p193 sig_type=std_logic lab=rd}
C {sky130_fd_pr/pfet3_01v8.sym} 4690 -6580 0 0 {name=M487
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4690 -6430 0 0 {name=M488
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4570 -6580 0 1 {name=M489
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4570 -6430 0 1 {name=M490
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4370 -6500 3 1 {name=M491
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4860 -6510 3 1 {name=M492
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 4630 -6340 0 0 {name=l210 lab=GND}
C {devices/vdd.sym} 4630 -6660 0 0 {name=l211 lab=VDD}
C {devices/lab_pin.sym} 4290 -6700 0 0 {name=p238 sig_type=std_logic lab=WL}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 3640 -6010 0 0 {name=X25}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 3620 -5380 0 0 {name=X26}
C {sky130_fd_pr/pfet3_01v8.sym} 3850 -6160 0 0 {name=M493
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3850 -6060 0 0 {name=M494
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3850 -5890 0 0 {name=M495
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3850 -5790 0 0 {name=M496
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3850 -5570 0 0 {name=M497
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3850 -5470 0 0 {name=M498
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3850 -5300 0 0 {name=M499
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3850 -5200 0 0 {name=M500
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 3870 -5130 0 0 {name=l212 lab=GND}
C {devices/gnd.sym} 3870 -5720 0 0 {name=l213 lab=GND}
C {devices/vdd.sym} 3870 -6230 0 0 {name=l214 lab=VDD}
C {devices/vdd.sym} 3870 -5620 0 0 {name=l215 lab=VDD}
C {devices/lab_pin.sym} 3470 -6010 0 0 {name=p239 sig_type=std_logic lab=we}
C {sky130_fd_pr/pfet3_01v8.sym} 3340 -6570 3 0 {name=M501
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3440 -6470 0 0 {name=M502
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3340 -6390 3 1 {name=M503
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 3270 -6290 3 0 {name=l216 lab=VDD}
C {devices/lab_pin.sym} 3420 -6300 3 0 {name=p240 sig_type=std_logic lab=p_b}
C {sky130_fd_pr/pfet3_01v8.sym} 4800 -6110 0 0 {name=M504
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4700 -6010 1 0 {name=M505
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4620 -6110 0 1 {name=M506
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 4520 -6180 0 0 {name=l217 lab=VDD}
C {devices/lab_pin.sym} 4530 -6030 0 0 {name=p241 sig_type=std_logic lab=p_b}
C {devices/lab_pin.sym} 4350 -5860 0 0 {name=p242 sig_type=std_logic lab=rd}
C {sky130_fd_pr/pfet3_01v8.sym} 4840 -5840 0 1 {name=M507
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4620 -5850 0 1 {name=M508
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4580 -5690 0 0 {name=M509
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4800 -5680 0 0 {name=M510
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4670 -5540 0 0 {name=M511
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 4570 -5540 0 0 {name=l218 lab=VDD}
C {devices/vdd.sym} 4780 -5890 0 0 {name=l219 lab=VDD}
C {devices/gnd.sym} 4690 -5480 0 0 {name=l220 lab=GND
value="pulse(0 1.8 1ns 1ns 1ns 4ns 10ns)"}
C {sky130_fd_pr/pfet3_01v8.sym} 5050 -5780 3 1 {name=M512
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4350 -5790 3 1 {name=M513
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 5050 -5840 0 0 {name=p245 sig_type=std_logic lab=rd}
C {sky130_fd_pr/pfet3_01v8.sym} 7010 -6560 0 0 {name=M514
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 7010 -6410 0 0 {name=M515
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 6890 -6560 0 1 {name=M516
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 6890 -6410 0 1 {name=M517
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 6690 -6480 3 1 {name=M518
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 7180 -6490 3 1 {name=M519
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 6950 -6320 0 0 {name=l221 lab=GND}
C {devices/vdd.sym} 6950 -6640 0 0 {name=l222 lab=VDD}
C {devices/lab_pin.sym} 6610 -6680 0 0 {name=p246 sig_type=std_logic lab=WL}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 5960 -5990 0 0 {name=X27}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 5940 -5360 0 0 {name=X28}
C {sky130_fd_pr/pfet3_01v8.sym} 6170 -6140 0 0 {name=M520
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 6170 -6040 0 0 {name=M521
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 6170 -5870 0 0 {name=M522
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 6170 -5770 0 0 {name=M523
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 6170 -5550 0 0 {name=M524
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 6170 -5450 0 0 {name=M525
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 6170 -5280 0 0 {name=M526
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 6170 -5180 0 0 {name=M527
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 6190 -5110 0 0 {name=l223 lab=GND}
C {devices/gnd.sym} 6190 -5700 0 0 {name=l224 lab=GND}
C {devices/vdd.sym} 6190 -6210 0 0 {name=l225 lab=VDD}
C {devices/vdd.sym} 6190 -5600 0 0 {name=l226 lab=VDD}
C {devices/lab_pin.sym} 5790 -5990 0 0 {name=p247 sig_type=std_logic lab=we}
C {sky130_fd_pr/pfet3_01v8.sym} 5660 -6550 3 0 {name=M528
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 5760 -6450 0 0 {name=M529
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 5660 -6370 3 1 {name=M530
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 5590 -6270 3 0 {name=l227 lab=VDD}
C {devices/lab_pin.sym} 5740 -6280 3 0 {name=p248 sig_type=std_logic lab=p_b}
C {sky130_fd_pr/pfet3_01v8.sym} 7120 -6090 0 0 {name=M531
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 7020 -5990 1 0 {name=M532
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 6940 -6090 0 1 {name=M533
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 6840 -6160 0 0 {name=l228 lab=VDD}
C {devices/lab_pin.sym} 6850 -6010 0 0 {name=p249 sig_type=std_logic lab=p_b}
C {sky130_fd_pr/pfet3_01v8.sym} 7160 -5820 0 1 {name=M534
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 6940 -5830 0 1 {name=M535
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 6900 -5670 0 0 {name=M536
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 7120 -5660 0 0 {name=M537
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 6990 -5520 0 0 {name=M538
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 6890 -5520 0 0 {name=l229 lab=VDD}
C {devices/vdd.sym} 7100 -5870 0 0 {name=l230 lab=VDD}
C {devices/gnd.sym} 7010 -5460 0 0 {name=l231 lab=GND
value="pulse(0 1.8 1ns 1ns 1ns 4ns 10ns)"}
C {sky130_fd_pr/pfet3_01v8.sym} 7370 -5760 3 1 {name=M539
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 6670 -5770 3 1 {name=M540
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 7370 -5820 0 0 {name=p250 sig_type=std_logic lab=rd}
C {sky130_fd_pr/pfet3_01v8.sym} 9160 -6550 0 0 {name=M541
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 9160 -6400 0 0 {name=M542
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 9040 -6550 0 1 {name=M543
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 9040 -6400 0 1 {name=M544
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 8840 -6470 3 1 {name=M545
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 9330 -6480 3 1 {name=M546
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 9100 -6310 0 0 {name=l232 lab=GND}
C {devices/vdd.sym} 9100 -6630 0 0 {name=l233 lab=VDD}
C {devices/lab_pin.sym} 8760 -6670 0 0 {name=p251 sig_type=std_logic lab=WL}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 8110 -5980 0 0 {name=X29}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 8090 -5350 0 0 {name=X30}
C {sky130_fd_pr/pfet3_01v8.sym} 8320 -6130 0 0 {name=M547
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 8320 -6030 0 0 {name=M548
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 8320 -5860 0 0 {name=M549
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 8320 -5760 0 0 {name=M550
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 8320 -5540 0 0 {name=M551
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 8320 -5440 0 0 {name=M552
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 8320 -5270 0 0 {name=M553
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 8320 -5170 0 0 {name=M554
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 8340 -5100 0 0 {name=l234 lab=GND}
C {devices/gnd.sym} 8340 -5690 0 0 {name=l235 lab=GND}
C {devices/vdd.sym} 8340 -6200 0 0 {name=l236 lab=VDD}
C {devices/vdd.sym} 8340 -5590 0 0 {name=l237 lab=VDD}
C {devices/lab_pin.sym} 7940 -5980 0 0 {name=p252 sig_type=std_logic lab=we}
C {sky130_fd_pr/pfet3_01v8.sym} 7810 -6540 3 0 {name=M555
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 7910 -6440 0 0 {name=M556
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 7810 -6360 3 1 {name=M557
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 7740 -6260 3 0 {name=l238 lab=VDD}
C {devices/lab_pin.sym} 7890 -6270 3 0 {name=p253 sig_type=std_logic lab=p_b}
C {sky130_fd_pr/pfet3_01v8.sym} 9270 -6080 0 0 {name=M558
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 9170 -5980 1 0 {name=M559
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 9090 -6080 0 1 {name=M560
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 8990 -6150 0 0 {name=l239 lab=VDD}
C {devices/lab_pin.sym} 9000 -6000 0 0 {name=p254 sig_type=std_logic lab=p_b}
C {devices/lab_pin.sym} 8820 -5830 0 0 {name=p255 sig_type=std_logic lab=rd}
C {sky130_fd_pr/pfet3_01v8.sym} 9310 -5810 0 1 {name=M561
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 9090 -5820 0 1 {name=M562
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 9050 -5660 0 0 {name=M563
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 9270 -5650 0 0 {name=M564
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 9140 -5510 0 0 {name=M565
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 9040 -5510 0 0 {name=l240 lab=VDD}
C {devices/vdd.sym} 9250 -5860 0 0 {name=l241 lab=VDD}
C {devices/gnd.sym} 9160 -5450 0 0 {name=l242 lab=GND
value="pulse(0 1.8 1ns 1ns 1ns 4ns 10ns)"}
C {sky130_fd_pr/pfet3_01v8.sym} 9520 -5750 3 1 {name=M566
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 8820 -5760 3 1 {name=M567
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 9520 -5810 0 0 {name=p256 sig_type=std_logic lab=rd}
C {sky130_fd_pr/pfet3_01v8.sym} 11290 -6550 0 0 {name=M568
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 11290 -6400 0 0 {name=M569
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 11170 -6550 0 1 {name=M570
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 11170 -6400 0 1 {name=M571
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 10970 -6470 3 1 {name=M572
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 11460 -6480 3 1 {name=M573
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 11230 -6310 0 0 {name=l243 lab=GND}
C {devices/vdd.sym} 11230 -6630 0 0 {name=l244 lab=VDD}
C {devices/lab_pin.sym} 10890 -6670 0 0 {name=p257 sig_type=std_logic lab=WL}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 10240 -5980 0 0 {name=X31}
C {/home/apn/test_xschem_sky130/inv_vtc.sym} 10220 -5350 0 0 {name=X32}
C {sky130_fd_pr/pfet3_01v8.sym} 10450 -6130 0 0 {name=M574
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 10450 -6030 0 0 {name=M575
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 10450 -5860 0 0 {name=M576
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 10450 -5760 0 0 {name=M577
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 10450 -5540 0 0 {name=M578
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 10450 -5440 0 0 {name=M579
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 10450 -5270 0 0 {name=M580
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 10450 -5170 0 0 {name=M581
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 10470 -5100 0 0 {name=l245 lab=GND}
C {devices/gnd.sym} 10470 -5690 0 0 {name=l246 lab=GND}
C {devices/vdd.sym} 10470 -6200 0 0 {name=l247 lab=VDD}
C {devices/vdd.sym} 10470 -5590 0 0 {name=l248 lab=VDD}
C {devices/lab_pin.sym} 10070 -5980 0 0 {name=p258 sig_type=std_logic lab=we}
C {sky130_fd_pr/pfet3_01v8.sym} 9940 -6540 3 0 {name=M582
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 10040 -6440 0 0 {name=M583
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 9940 -6360 3 1 {name=M584
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 9870 -6260 3 0 {name=l249 lab=VDD}
C {devices/lab_pin.sym} 10020 -6270 3 0 {name=p259 sig_type=std_logic lab=p_b}
C {sky130_fd_pr/pfet3_01v8.sym} 11400 -6080 0 0 {name=M585
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 11300 -5980 1 0 {name=M586
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 11220 -6080 0 1 {name=M587
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 11120 -6150 0 0 {name=l250 lab=VDD}
C {devices/lab_pin.sym} 11130 -6000 0 0 {name=p260 sig_type=std_logic lab=p_b}
C {devices/lab_pin.sym} 10950 -5830 0 0 {name=p261 sig_type=std_logic lab=rd}
C {sky130_fd_pr/pfet3_01v8.sym} 11440 -5810 0 1 {name=M588
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 11220 -5820 0 1 {name=M589
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 11180 -5660 0 0 {name=M590
W=1
L=0.15
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 11400 -5650 0 0 {name=M591
W=1
L=0.15
body=GND
nf=1
mult=1
