v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 640 -1470 5160 -1470 {
lab=#net1}
N 690 -1440 690 -1410 {
lab=d0}
N 710 -1440 710 -1410 {
lab=#net2}
N 730 -1440 730 -1410 {
lab=#net3}
N 770 -1440 770 -1410 {
lab=#net4}
N 790 -1440 790 -1410 {
lab=#net1}
N 830 -1440 830 -1410 {
lab=d1}
N 850 -1440 850 -1410 {
lab=#net2}
N 870 -1440 870 -1410 {
lab=#net3}
N 910 -1440 910 -1410 {
lab=#net4}
N 930 -1440 930 -1410 {
lab=#net1}
N 970 -1440 970 -1410 {
lab=d2}
N 990 -1440 990 -1410 {
lab=#net2}
N 1010 -1440 1010 -1410 {
lab=#net3}
N 1050 -1440 1050 -1410 {
lab=#net4}
N 1070 -1440 1070 -1410 {
lab=#net1}
N 1110 -1440 1110 -1410 {
lab=d3}
N 1130 -1440 1130 -1410 {
lab=#net2}
N 1150 -1440 1150 -1410 {
lab=#net3}
N 1190 -1440 1190 -1410 {
lab=#net4}
N 1210 -1440 1210 -1410 {
lab=#net1}
N 1250 -1440 1250 -1410 {
lab=d4}
N 1270 -1440 1270 -1410 {
lab=#net2}
N 1290 -1440 1290 -1410 {
lab=#net3}
N 1330 -1440 1330 -1410 {
lab=#net4}
N 1350 -1440 1350 -1410 {
lab=#net1}
N 1390 -1440 1390 -1410 {
lab=d5}
N 1410 -1440 1410 -1410 {
lab=#net2}
N 1430 -1440 1430 -1410 {
lab=#net3}
N 1470 -1440 1470 -1410 {
lab=#net4}
N 1490 -1440 1490 -1410 {
lab=#net1}
N 1530 -1440 1530 -1410 {
lab=d6}
N 1550 -1440 1550 -1410 {
lab=#net2}
N 1570 -1440 1570 -1410 {
lab=#net3}
N 1610 -1440 1610 -1410 {
lab=#net4}
N 1630 -1440 1630 -1410 {
lab=#net1}
N 1670 -1440 1670 -1410 {
lab=d7}
N 1690 -1440 1690 -1410 {
lab=#net2}
N 1710 -1440 1710 -1410 {
lab=#net3}
N 1750 -1440 1750 -1410 {
lab=#net4}
N 1770 -1440 1770 -1410 {
lab=#net1}
N 1810 -1440 1810 -1410 {
lab=d8}
N 1830 -1440 1830 -1410 {
lab=#net2}
N 1850 -1440 1850 -1410 {
lab=#net3}
N 1890 -1440 1890 -1410 {
lab=#net4}
N 1910 -1440 1910 -1410 {
lab=#net1}
N 1950 -1440 1950 -1410 {
lab=d9}
N 1970 -1440 1970 -1410 {
lab=#net2}
N 1990 -1440 1990 -1410 {
lab=#net3}
N 2030 -1440 2030 -1410 {
lab=#net4}
N 2050 -1440 2050 -1410 {
lab=#net1}
N 2090 -1440 2090 -1410 {
lab=d10}
N 2110 -1440 2110 -1410 {
lab=#net2}
N 2130 -1440 2130 -1410 {
lab=#net3}
N 2170 -1440 2170 -1410 {
lab=#net4}
N 2190 -1440 2190 -1410 {
lab=#net1}
N 2230 -1440 2230 -1410 {
lab=d11}
N 2250 -1440 2250 -1410 {
lab=#net2}
N 2270 -1440 2270 -1410 {
lab=#net3}
N 2310 -1440 2310 -1410 {
lab=#net4}
N 2330 -1440 2330 -1410 {
lab=#net1}
N 2370 -1440 2370 -1410 {
lab=d12}
N 2390 -1440 2390 -1410 {
lab=#net5}
N 2410 -1440 2410 -1410 {
lab=#net3}
N 2450 -1440 2450 -1410 {
lab=#net4}
N 2470 -1440 2470 -1410 {
lab=#net1}
N 2510 -1440 2510 -1410 {
lab=d13}
N 2530 -1440 2530 -1410 {
lab=#net2}
N 2550 -1440 2550 -1410 {
lab=#net3}
N 2590 -1440 2590 -1410 {
lab=#net4}
N 2610 -1440 2610 -1410 {
lab=#net1}
N 2650 -1440 2650 -1410 {
lab=d14}
N 2670 -1440 2670 -1410 {
lab=#net2}
N 2690 -1440 2690 -1410 {
lab=#net3}
N 2730 -1440 2730 -1410 {
lab=#net4}
N 2750 -1440 2750 -1410 {
lab=#net1}
N 2790 -1440 2790 -1410 {
lab=d15}
N 2810 -1440 2810 -1410 {
lab=#net2}
N 2830 -1440 2830 -1410 {
lab=#net3}
N 2870 -1440 2870 -1410 {
lab=#net4}
N 2890 -1440 2890 -1410 {
lab=#net1}
N 2930 -1440 2930 -1410 {
lab=d16}
N 2950 -1440 2950 -1410 {
lab=#net2}
N 2970 -1440 2970 -1410 {
lab=#net3}
N 3010 -1440 3010 -1410 {
lab=#net4}
N 3030 -1440 3030 -1410 {
lab=#net1}
N 3070 -1440 3070 -1410 {
lab=d17}
N 3090 -1440 3090 -1410 {
lab=#net2}
N 3110 -1440 3110 -1410 {
lab=#net3}
N 3150 -1440 3150 -1410 {
lab=#net4}
N 3170 -1440 3170 -1410 {
lab=#net1}
N 3210 -1440 3210 -1410 {
lab=d18}
N 3230 -1440 3230 -1410 {
lab=#net2}
N 3250 -1440 3250 -1410 {
lab=#net3}
N 3290 -1440 3290 -1410 {
lab=#net4}
N 3310 -1440 3310 -1410 {
lab=#net1}
N 3350 -1440 3350 -1410 {
lab=d19}
N 3370 -1440 3370 -1410 {
lab=#net2}
N 3390 -1440 3390 -1410 {
lab=#net3}
N 3430 -1440 3430 -1410 {
lab=#net4}
N 3450 -1440 3450 -1410 {
lab=#net1}
N 3490 -1440 3490 -1410 {
lab=d20}
N 3510 -1440 3510 -1410 {
lab=#net2}
N 3530 -1440 3530 -1410 {
lab=#net3}
N 3570 -1440 3570 -1410 {
lab=#net4}
N 3590 -1440 3590 -1410 {
lab=#net1}
N 3630 -1440 3630 -1410 {
lab=d21}
N 3650 -1440 3650 -1410 {
lab=#net2}
N 3670 -1440 3670 -1410 {
lab=#net3}
N 3710 -1440 3710 -1410 {
lab=#net4}
N 3730 -1440 3730 -1410 {
lab=#net1}
N 3770 -1440 3770 -1410 {
lab=d22}
N 3790 -1440 3790 -1410 {
lab=#net2}
N 3810 -1440 3810 -1410 {
lab=#net3}
N 3850 -1440 3850 -1410 {
lab=#net4}
N 3870 -1440 3870 -1410 {
lab=#net1}
N 3910 -1440 3910 -1410 {
lab=d23}
N 3930 -1440 3930 -1410 {
lab=#net2}
N 3950 -1440 3950 -1410 {
lab=#net3}
N 3990 -1440 3990 -1410 {
lab=#net4}
N 4010 -1440 4010 -1410 {
lab=#net1}
N 4050 -1440 4050 -1410 {
lab=d24}
N 4070 -1440 4070 -1410 {
lab=#net2}
N 4090 -1440 4090 -1410 {
lab=#net3}
N 4130 -1440 4130 -1410 {
lab=#net4}
N 4150 -1440 4150 -1410 {
lab=#net1}
N 4190 -1440 4190 -1410 {
lab=d25}
N 4210 -1440 4210 -1410 {
lab=#net2}
N 4230 -1440 4230 -1410 {
lab=#net3}
N 4270 -1440 4270 -1410 {
lab=#net4}
N 4290 -1440 4290 -1410 {
lab=#net1}
N 4330 -1440 4330 -1410 {
lab=d26}
N 4350 -1440 4350 -1410 {
lab=#net2}
N 4370 -1440 4370 -1410 {
lab=#net3}
N 4410 -1440 4410 -1410 {
lab=#net4}
N 4430 -1440 4430 -1410 {
lab=#net1}
N 4470 -1440 4470 -1410 {
lab=d27}
N 4490 -1440 4490 -1410 {
lab=#net2}
N 4510 -1440 4510 -1410 {
lab=#net3}
N 4550 -1440 4550 -1410 {
lab=#net4}
N 4570 -1440 4570 -1410 {
lab=#net1}
N 4610 -1440 4610 -1410 {
lab=d28}
N 4630 -1440 4630 -1410 {
lab=#net2}
N 4650 -1440 4650 -1410 {
lab=#net3}
N 4690 -1440 4690 -1410 {
lab=#net4}
N 4710 -1440 4710 -1410 {
lab=#net1}
N 4750 -1440 4750 -1410 {
lab=d29}
N 4770 -1440 4770 -1410 {
lab=#net2}
N 4790 -1440 4790 -1410 {
lab=#net3}
N 4830 -1440 4830 -1410 {
lab=#net4}
N 4850 -1440 4850 -1410 {
lab=#net1}
N 4890 -1440 4890 -1410 {
lab=d30}
N 4910 -1440 4910 -1410 {
lab=#net2}
N 4930 -1440 4930 -1410 {
lab=#net3}
N 4970 -1440 4970 -1410 {
lab=#net4}
N 4990 -1440 4990 -1410 {
lab=#net1}
N 5030 -1440 5030 -1410 {
lab=d31}
N 5050 -1440 5050 -1410 {
lab=#net2}
N 5070 -1440 5070 -1410 {
lab=#net3}
N 5110 -1440 5110 -1410 {
lab=#net4}
N 5130 -1440 5130 -1410 {
lab=#net1}
N 690 -1110 690 -1080 {
lab=o}
N 710 -1110 710 -1080 {
lab=ob}
N 730 -1110 730 -1080 {
lab=blb}
N 750 -1110 750 -1080 {
lab=b}
N 770 -1110 770 -1080 {
lab=q}
N 790 -1110 790 -1080 {
lab=d0}
N 830 -1110 830 -1080 {
lab=#net6}
N 850 -1110 850 -1080 {
lab=#net7}
N 870 -1110 870 -1080 {
lab=#net8}
N 890 -1110 890 -1080 {
lab=#net9}
N 910 -1110 910 -1080 {
lab=#net10}
N 930 -1110 930 -1080 {
lab=#net11}
N 970 -1110 970 -1080 {
lab=#net12}
N 990 -1110 990 -1080 {
lab=#net13}
N 1010 -1110 1010 -1080 {
lab=#net14}
N 1030 -1110 1030 -1080 {
lab=#net15}
N 1050 -1110 1050 -1080 {
lab=#net16}
N 1070 -1110 1070 -1080 {
lab=#net17}
N 1110 -1110 1110 -1080 {
lab=#net18}
N 1130 -1110 1130 -1080 {
lab=#net19}
N 1150 -1110 1150 -1080 {
lab=#net20}
N 1170 -1110 1170 -1080 {
lab=#net21}
N 1190 -1110 1190 -1080 {
lab=#net22}
N 1210 -1110 1210 -1080 {
lab=#net23}
N 1250 -1110 1250 -1080 {
lab=#net24}
N 1270 -1110 1270 -1080 {
lab=#net25}
N 1290 -1110 1290 -1080 {
lab=#net26}
N 1310 -1110 1310 -1080 {
lab=#net27}
N 1330 -1110 1330 -1080 {
lab=#net28}
N 1350 -1110 1350 -1080 {
lab=#net29}
N 1390 -1110 1390 -1080 {
lab=#net30}
N 1410 -1110 1410 -1080 {
lab=#net31}
N 1430 -1110 1430 -1080 {
lab=#net32}
N 1450 -1110 1450 -1080 {
lab=#net33}
N 1470 -1110 1470 -1080 {
lab=#net34}
N 1490 -1110 1490 -1080 {
lab=#net35}
N 1530 -1110 1530 -1080 {
lab=#net36}
N 1550 -1110 1550 -1080 {
lab=#net37}
N 1570 -1110 1570 -1080 {
lab=#net38}
N 1590 -1110 1590 -1080 {
lab=#net39}
N 1610 -1110 1610 -1080 {
lab=#net40}
N 1630 -1110 1630 -1080 {
lab=#net41}
N 1670 -1110 1670 -1080 {
lab=#net42}
N 1690 -1110 1690 -1080 {
lab=#net43}
N 1710 -1110 1710 -1080 {
lab=#net44}
N 1730 -1110 1730 -1080 {
lab=#net45}
N 1750 -1110 1750 -1080 {
lab=#net46}
N 1770 -1110 1770 -1080 {
lab=#net47}
N 1810 -1110 1810 -1080 {
lab=#net48}
N 1830 -1110 1830 -1080 {
lab=#net49}
N 1850 -1110 1850 -1080 {
lab=#net50}
N 1870 -1110 1870 -1080 {
lab=#net51}
N 1890 -1110 1890 -1080 {
lab=#net52}
N 1910 -1110 1910 -1080 {
lab=#net53}
N 1950 -1110 1950 -1080 {
lab=#net54}
N 1970 -1110 1970 -1080 {
lab=#net55}
N 1990 -1110 1990 -1080 {
lab=#net56}
N 2010 -1110 2010 -1080 {
lab=#net57}
N 2030 -1110 2030 -1080 {
lab=#net58}
N 2050 -1110 2050 -1080 {
lab=#net59}
N 2090 -1110 2090 -1080 {
lab=#net60}
N 2110 -1110 2110 -1080 {
lab=#net61}
N 2130 -1110 2130 -1080 {
lab=#net62}
N 2150 -1110 2150 -1080 {
lab=#net63}
N 2170 -1110 2170 -1080 {
lab=#net64}
N 2190 -1110 2190 -1080 {
lab=#net65}
N 2230 -1110 2230 -1080 {
lab=#net66}
N 2250 -1110 2250 -1080 {
lab=#net67}
N 2270 -1110 2270 -1080 {
lab=#net68}
N 2290 -1110 2290 -1080 {
lab=#net69}
N 2310 -1110 2310 -1080 {
lab=#net70}
N 2330 -1110 2330 -1080 {
lab=#net71}
N 2370 -1110 2370 -1080 {
lab=#net72}
N 2390 -1110 2390 -1080 {
lab=#net73}
N 2410 -1110 2410 -1080 {
lab=#net74}
N 2430 -1110 2430 -1080 {
lab=#net75}
N 2450 -1110 2450 -1080 {
lab=#net76}
N 2470 -1110 2470 -1080 {
lab=#net77}
N 2510 -1110 2510 -1080 {
lab=#net78}
N 2530 -1110 2530 -1080 {
lab=#net79}
N 2550 -1110 2550 -1080 {
lab=#net80}
N 2570 -1110 2570 -1080 {
lab=#net81}
N 2590 -1110 2590 -1080 {
lab=#net82}
N 2610 -1110 2610 -1080 {
lab=#net83}
N 2650 -1110 2650 -1080 {
lab=#net84}
N 2670 -1110 2670 -1080 {
lab=#net85}
N 2690 -1110 2690 -1080 {
lab=#net86}
N 2710 -1110 2710 -1080 {
lab=#net87}
N 2730 -1110 2730 -1080 {
lab=#net88}
N 2750 -1110 2750 -1080 {
lab=#net89}
N 2790 -1110 2790 -1080 {
lab=#net90}
N 2810 -1110 2810 -1080 {
lab=#net91}
N 2830 -1110 2830 -1080 {
lab=#net92}
N 2850 -1110 2850 -1080 {
lab=#net93}
N 2870 -1110 2870 -1080 {
lab=#net94}
N 2890 -1110 2890 -1080 {
lab=#net95}
N 2930 -1110 2930 -1080 {
lab=#net96}
N 2950 -1110 2950 -1080 {
lab=#net97}
N 2970 -1110 2970 -1080 {
lab=#net98}
N 2990 -1110 2990 -1080 {
lab=#net99}
N 3010 -1110 3010 -1080 {
lab=#net100}
N 3030 -1110 3030 -1080 {
lab=#net101}
N 3070 -1110 3070 -1080 {
lab=#net102}
N 3090 -1110 3090 -1080 {
lab=#net103}
N 3110 -1110 3110 -1080 {
lab=#net104}
N 3130 -1110 3130 -1080 {
lab=#net105}
N 3150 -1110 3150 -1080 {
lab=#net106}
N 3170 -1110 3170 -1080 {
lab=#net107}
N 3210 -1110 3210 -1080 {
lab=#net108}
N 3230 -1110 3230 -1080 {
lab=#net109}
N 3250 -1110 3250 -1080 {
lab=#net110}
N 3270 -1110 3270 -1080 {
lab=#net111}
N 3290 -1110 3290 -1080 {
lab=#net112}
N 3310 -1110 3310 -1080 {
lab=#net113}
N 3350 -1110 3350 -1080 {
lab=#net114}
N 3370 -1110 3370 -1080 {
lab=#net115}
N 3390 -1110 3390 -1080 {
lab=#net116}
N 3410 -1110 3410 -1080 {
lab=#net117}
N 3430 -1110 3430 -1080 {
lab=#net118}
N 3450 -1110 3450 -1080 {
lab=#net119}
N 3490 -1110 3490 -1080 {
lab=#net120}
N 3510 -1110 3510 -1080 {
lab=#net121}
N 3530 -1110 3530 -1080 {
lab=#net122}
N 3550 -1110 3550 -1080 {
lab=#net123}
N 3570 -1110 3570 -1080 {
lab=#net124}
N 3590 -1110 3590 -1080 {
lab=#net125}
N 3630 -1110 3630 -1080 {
lab=#net126}
N 3650 -1110 3650 -1080 {
lab=#net127}
N 3670 -1110 3670 -1080 {
lab=#net128}
N 3690 -1110 3690 -1080 {
lab=#net129}
N 3710 -1110 3710 -1080 {
lab=#net130}
N 3730 -1110 3730 -1080 {
lab=#net131}
N 3770 -1110 3770 -1080 {
lab=#net132}
N 3790 -1110 3790 -1080 {
lab=#net133}
N 3810 -1110 3810 -1080 {
lab=#net134}
N 3830 -1110 3830 -1080 {
lab=#net135}
N 3850 -1110 3850 -1080 {
lab=#net136}
N 3870 -1110 3870 -1080 {
lab=#net137}
N 3910 -1110 3910 -1080 {
lab=#net138}
N 3930 -1110 3930 -1080 {
lab=#net139}
N 3950 -1110 3950 -1080 {
lab=#net140}
N 3970 -1110 3970 -1080 {
lab=#net141}
N 3990 -1110 3990 -1080 {
lab=#net142}
N 4010 -1110 4010 -1080 {
lab=#net143}
N 4050 -1110 4050 -1080 {
lab=#net144}
N 4070 -1110 4070 -1080 {
lab=#net145}
N 4090 -1110 4090 -1080 {
lab=#net146}
N 4110 -1110 4110 -1080 {
lab=#net147}
N 4130 -1110 4130 -1080 {
lab=#net148}
N 4150 -1110 4150 -1080 {
lab=#net149}
N 4190 -1110 4190 -1080 {
lab=#net150}
N 4210 -1110 4210 -1080 {
lab=#net151}
N 4230 -1110 4230 -1080 {
lab=#net152}
N 4250 -1110 4250 -1080 {
lab=#net153}
N 4270 -1110 4270 -1080 {
lab=#net154}
N 4290 -1110 4290 -1080 {
lab=#net155}
N 4330 -1110 4330 -1080 {
lab=#net156}
N 4350 -1110 4350 -1080 {
lab=#net157}
N 4370 -1110 4370 -1080 {
lab=#net158}
N 4390 -1110 4390 -1080 {
lab=#net159}
N 4410 -1110 4410 -1080 {
lab=#net160}
N 4430 -1110 4430 -1080 {
lab=#net161}
N 4470 -1110 4470 -1080 {
lab=#net162}
N 4490 -1110 4490 -1080 {
lab=#net163}
N 4510 -1110 4510 -1080 {
lab=#net164}
N 4530 -1110 4530 -1080 {
lab=#net165}
N 4550 -1110 4550 -1080 {
lab=#net166}
N 4570 -1110 4570 -1080 {
lab=#net167}
N 4610 -1110 4610 -1080 {
lab=#net168}
N 4630 -1110 4630 -1080 {
lab=#net169}
N 4650 -1110 4650 -1080 {
lab=#net170}
N 4670 -1110 4670 -1080 {
lab=#net171}
N 4690 -1110 4690 -1080 {
lab=#net172}
N 4710 -1110 4710 -1080 {
lab=#net173}
N 4750 -1110 4750 -1080 {
lab=#net174}
N 4770 -1110 4770 -1080 {
lab=#net175}
N 4790 -1110 4790 -1080 {
lab=#net176}
N 4810 -1110 4810 -1080 {
lab=#net177}
N 4830 -1110 4830 -1080 {
lab=#net178}
N 4850 -1110 4850 -1080 {
lab=#net179}
N 4890 -1110 4890 -1080 {
lab=#net180}
N 4910 -1110 4910 -1080 {
lab=#net181}
N 4930 -1110 4930 -1080 {
lab=#net182}
N 4950 -1110 4950 -1080 {
lab=#net183}
N 4970 -1110 4970 -1080 {
lab=#net184}
N 4990 -1110 4990 -1080 {
lab=#net185}
N 5030 -1110 5030 -1080 {
lab=#net186}
N 5050 -1110 5050 -1080 {
lab=#net187}
N 5070 -1110 5070 -1080 {
lab=#net188}
N 5090 -1110 5090 -1080 {
lab=#net189}
N 5110 -1110 5110 -1080 {
lab=#net190}
N 5130 -1110 5130 -1080 {
lab=#net191}
N 790 -1470 790 -1440 {
lab=#net1}
N 930 -1470 930 -1440 {
lab=#net1}
N 1070 -1470 1070 -1440 {
lab=#net1}
N 1210 -1470 1210 -1440 {
lab=#net1}
N 1350 -1470 1350 -1440 {
lab=#net1}
N 1490 -1470 1490 -1440 {
lab=#net1}
N 1630 -1470 1630 -1440 {
lab=#net1}
N 1770 -1470 1770 -1440 {
lab=#net1}
N 1910 -1470 1910 -1440 {
lab=#net1}
N 2050 -1470 2050 -1440 {
lab=#net1}
N 2190 -1470 2190 -1440 {
lab=#net1}
N 2330 -1470 2330 -1440 {
lab=#net1}
N 2470 -1470 2470 -1440 {
lab=#net1}
N 2610 -1470 2610 -1440 {
lab=#net1}
N 2750 -1470 2750 -1440 {
lab=#net1}
N 2890 -1470 2890 -1440 {
lab=#net1}
N 3030 -1470 3030 -1440 {
lab=#net1}
N 3170 -1470 3170 -1440 {
lab=#net1}
N 3310 -1470 3310 -1440 {
lab=#net1}
N 3450 -1470 3450 -1440 {
lab=#net1}
N 3590 -1470 3590 -1440 {
lab=#net1}
N 3730 -1470 3730 -1440 {
lab=#net1}
N 3870 -1470 3870 -1440 {
lab=#net1}
N 4010 -1470 4010 -1440 {
lab=#net1}
N 4150 -1470 4150 -1440 {
lab=#net1}
N 4290 -1470 4290 -1440 {
lab=#net1}
N 4430 -1470 4430 -1440 {
lab=#net1}
N 4570 -1470 4570 -1440 {
lab=#net1}
N 4710 -1470 4710 -1440 {
lab=#net1}
N 4850 -1470 4850 -1440 {
lab=#net1}
N 4990 -1470 4990 -1440 {
lab=#net1}
N 5130 -1470 5130 -1440 {
lab=#net1}
N 640 -1500 5160 -1500 {
lab=#net3}
N 730 -1500 730 -1440 {
lab=#net3}
N 870 -1500 870 -1440 {
lab=#net3}
N 1010 -1500 1010 -1440 {
lab=#net3}
N 1150 -1500 1150 -1440 {
lab=#net3}
N 1290 -1500 1290 -1440 {
lab=#net3}
N 1430 -1500 1430 -1440 {
lab=#net3}
N 1570 -1500 1570 -1440 {
lab=#net3}
N 1710 -1500 1710 -1440 {
lab=#net3}
N 1850 -1500 1850 -1440 {
lab=#net3}
N 1990 -1500 1990 -1440 {
lab=#net3}
N 2130 -1500 2130 -1440 {
lab=#net3}
N 2270 -1500 2270 -1440 {
lab=#net3}
N 2410 -1500 2410 -1440 {
lab=#net3}
N 2550 -1500 2550 -1440 {
lab=#net3}
N 2690 -1500 2690 -1440 {
lab=#net3}
N 2830 -1500 2830 -1440 {
lab=#net3}
N 2970 -1500 2970 -1440 {
lab=#net3}
N 3110 -1500 3110 -1440 {
lab=#net3}
N 3250 -1500 3250 -1440 {
lab=#net3}
N 3390 -1500 3390 -1440 {
lab=#net3}
N 3530 -1500 3530 -1440 {
lab=#net3}
N 3670 -1500 3670 -1440 {
lab=#net3}
N 3810 -1500 3810 -1440 {
lab=#net3}
N 3950 -1500 3950 -1440 {
lab=#net3}
N 4090 -1500 4090 -1440 {
lab=#net3}
N 4230 -1500 4230 -1440 {
lab=#net3}
N 4370 -1500 4370 -1440 {
lab=#net3}
N 4510 -1500 4510 -1440 {
lab=#net3}
N 4650 -1500 4650 -1440 {
lab=#net3}
N 4790 -1500 4790 -1440 {
lab=#net3}
N 4930 -1500 4930 -1440 {
lab=#net3}
N 5070 -1500 5070 -1440 {
lab=#net3}
N 640 -1530 5160 -1530 {
lab=#net2}
N 710 -1530 710 -1440 {
lab=#net2}
N 850 -1530 850 -1440 {
lab=#net2}
N 990 -1530 990 -1440 {
lab=#net2}
N 1130 -1530 1130 -1440 {
lab=#net2}
N 1270 -1530 1270 -1440 {
lab=#net2}
N 1410 -1530 1410 -1440 {
lab=#net2}
N 1550 -1530 1550 -1440 {
lab=#net2}
N 1690 -1530 1690 -1440 {
lab=#net2}
N 1830 -1530 1830 -1440 {
lab=#net2}
N 1970 -1530 1970 -1440 {
lab=#net2}
N 2110 -1530 2110 -1440 {
lab=#net2}
N 2250 -1530 2250 -1440 {
lab=#net2}
N 2530 -1530 2530 -1440 {
lab=#net2}
N 2670 -1530 2670 -1440 {
lab=#net2}
N 2810 -1530 2810 -1440 {
lab=#net2}
N 2950 -1530 2950 -1440 {
lab=#net2}
N 3090 -1530 3090 -1440 {
lab=#net2}
N 3230 -1530 3230 -1440 {
lab=#net2}
N 3370 -1530 3370 -1440 {
lab=#net2}
N 3510 -1530 3510 -1440 {
lab=#net2}
N 3650 -1530 3650 -1440 {
lab=#net2}
N 3790 -1530 3790 -1440 {
lab=#net2}
N 3930 -1530 3930 -1440 {
lab=#net2}
N 4070 -1530 4070 -1440 {
lab=#net2}
N 4210 -1530 4210 -1440 {
lab=#net2}
N 4350 -1530 4350 -1440 {
lab=#net2}
N 4490 -1530 4490 -1440 {
lab=#net2}
N 4630 -1530 4630 -1440 {
lab=#net2}
N 4770 -1530 4770 -1440 {
lab=#net2}
N 4910 -1530 4910 -1440 {
lab=#net2}
N 5050 -1530 5050 -1440 {
lab=#net2}
N 640 -1560 5160 -1560 {
lab=#net4}
N 770 -1560 770 -1440 {
lab=#net4}
N 910 -1560 910 -1440 {
lab=#net4}
N 1050 -1560 1050 -1440 {
lab=#net4}
N 1190 -1560 1190 -1440 {
lab=#net4}
N 1330 -1560 1330 -1440 {
lab=#net4}
N 1470 -1560 1470 -1440 {
lab=#net4}
N 1610 -1560 1610 -1440 {
lab=#net4}
N 1750 -1560 1750 -1440 {
lab=#net4}
N 1890 -1560 1890 -1440 {
lab=#net4}
N 2030 -1560 2030 -1440 {
lab=#net4}
N 2170 -1560 2170 -1440 {
lab=#net4}
N 2310 -1560 2310 -1440 {
lab=#net4}
N 2450 -1560 2450 -1440 {
lab=#net4}
N 2590 -1560 2590 -1440 {
lab=#net4}
N 2730 -1560 2730 -1440 {
lab=#net4}
N 2870 -1560 2870 -1440 {
lab=#net4}
N 3010 -1560 3010 -1440 {
lab=#net4}
N 3150 -1560 3150 -1440 {
lab=#net4}
N 3290 -1560 3290 -1440 {
lab=#net4}
N 3430 -1560 3430 -1440 {
lab=#net4}
N 3570 -1560 3570 -1440 {
lab=#net4}
N 3710 -1560 3710 -1440 {
lab=#net4}
N 3850 -1560 3850 -1440 {
lab=#net4}
N 3990 -1560 3990 -1440 {
lab=#net4}
N 4130 -1560 4130 -1440 {
lab=#net4}
N 4270 -1560 4270 -1440 {
lab=#net4}
N 4410 -1560 4410 -1440 {
lab=#net4}
N 4550 -1560 4550 -1440 {
lab=#net4}
N 4690 -1560 4690 -1440 {
lab=#net4}
N 4830 -1560 4830 -1440 {
lab=#net4}
N 4970 -1560 4970 -1440 {
lab=#net4}
N 5110 -1560 5110 -1440 {
lab=#net4}
C {Memory/1x1 bit sram.sym} 740 -1260 1 0 {name=x1}
C {Memory/1x1 bit sram.sym} 880 -1260 1 0 {name=x2}
C {Memory/1x1 bit sram.sym} 1020 -1260 1 0 {name=x3}
C {Memory/1x1 bit sram.sym} 1160 -1260 1 0 {name=x4}
C {Memory/1x1 bit sram.sym} 1300 -1260 1 0 {name=x5}
C {Memory/1x1 bit sram.sym} 1440 -1260 1 0 {name=x6}
C {Memory/1x1 bit sram.sym} 1580 -1260 1 0 {name=x7}
C {Memory/1x1 bit sram.sym} 1720 -1260 1 0 {name=x8}
C {Memory/1x1 bit sram.sym} 1860 -1260 1 0 {name=x9}
C {Memory/1x1 bit sram.sym} 2000 -1260 1 0 {name=x10}
C {Memory/1x1 bit sram.sym} 2140 -1260 1 0 {name=x11}
C {Memory/1x1 bit sram.sym} 2280 -1260 1 0 {name=x12}
C {Memory/1x1 bit sram.sym} 2420 -1260 1 0 {name=x13}
C {Memory/1x1 bit sram.sym} 2560 -1260 1 0 {name=x14}
C {Memory/1x1 bit sram.sym} 2700 -1260 1 0 {name=x15}
C {Memory/1x1 bit sram.sym} 2840 -1260 1 0 {name=x16}
C {Memory/1x1 bit sram.sym} 2980 -1260 1 0 {name=x17}
C {Memory/1x1 bit sram.sym} 3120 -1260 1 0 {name=x18}
C {Memory/1x1 bit sram.sym} 3260 -1260 1 0 {name=x19}
C {Memory/1x1 bit sram.sym} 3400 -1260 1 0 {name=x20}
C {Memory/1x1 bit sram.sym} 3540 -1260 1 0 {name=x21}
C {Memory/1x1 bit sram.sym} 3680 -1260 1 0 {name=x22}
C {Memory/1x1 bit sram.sym} 3820 -1260 1 0 {name=x23}
C {Memory/1x1 bit sram.sym} 3960 -1260 1 0 {name=x24}
C {Memory/1x1 bit sram.sym} 4100 -1260 1 0 {name=x25}
C {Memory/1x1 bit sram.sym} 4240 -1260 1 0 {name=x26}
C {Memory/1x1 bit sram.sym} 4380 -1260 1 0 {name=x27}
C {Memory/1x1 bit sram.sym} 4520 -1260 1 0 {name=x28}
C {Memory/1x1 bit sram.sym} 4660 -1260 1 0 {name=x29}
C {Memory/1x1 bit sram.sym} 4800 -1260 1 0 {name=x30}
C {Memory/1x1 bit sram.sym} 4940 -1260 1 0 {name=x31}
C {Memory/1x1 bit sram.sym} 5080 -1260 1 0 {name=x32}
C {devices/lab_pin.sym} 690 -1440 0 0 {name=p1 sig_type=std_logic lab=d0}
C {devices/lab_pin.sym} 830 -1440 0 0 {name=p2 sig_type=std_logic lab=d1}
C {devices/lab_pin.sym} 970 -1440 0 0 {name=p3 sig_type=std_logic lab=d2}
C {devices/lab_pin.sym} 1110 -1440 0 0 {name=p4 sig_type=std_logic lab=d3}
C {devices/lab_pin.sym} 1250 -1440 0 0 {name=p5 sig_type=std_logic lab=d4}
C {devices/lab_pin.sym} 1390 -1440 0 0 {name=p6 sig_type=std_logic lab=d5}
C {devices/lab_pin.sym} 1530 -1440 0 0 {name=p7 sig_type=std_logic lab=d6}
C {devices/lab_pin.sym} 1670 -1440 0 0 {name=p8 sig_type=std_logic lab=d7}
C {devices/lab_pin.sym} 1810 -1440 0 0 {name=p9 sig_type=std_logic lab=d8}
C {devices/lab_pin.sym} 1950 -1440 0 0 {name=p10 sig_type=std_logic lab=d9}
C {devices/lab_pin.sym} 2090 -1440 0 0 {name=p11 sig_type=std_logic lab=d10}
C {devices/lab_pin.sym} 2510 -1440 0 0 {name=p12 sig_type=std_logic lab=d13}
C {devices/lab_pin.sym} 2650 -1440 0 0 {name=p13 sig_type=std_logic lab=d14}
C {devices/lab_pin.sym} 2230 -1440 0 0 {name=p14 sig_type=std_logic lab=d11}
C {devices/lab_pin.sym} 2370 -1440 0 0 {name=p15 sig_type=std_logic lab=d12}
C {devices/lab_pin.sym} 2790 -1440 0 0 {name=p16 sig_type=std_logic lab=d15}
C {devices/lab_pin.sym} 2930 -1440 0 0 {name=p17 sig_type=std_logic lab=d16}
C {devices/lab_pin.sym} 3070 -1440 0 0 {name=p18 sig_type=std_logic lab=d17}
C {devices/lab_pin.sym} 3210 -1440 0 0 {name=p19 sig_type=std_logic lab=d18}
C {devices/lab_pin.sym} 3350 -1440 0 0 {name=p20 sig_type=std_logic lab=d19}
C {devices/lab_pin.sym} 3490 -1440 0 0 {name=p21 sig_type=std_logic lab=d20}
C {devices/lab_pin.sym} 3630 -1440 0 0 {name=p22 sig_type=std_logic lab=d21}
C {devices/lab_pin.sym} 3770 -1440 0 0 {name=p23 sig_type=std_logic lab=d22}
C {devices/lab_pin.sym} 3910 -1440 0 0 {name=p24 sig_type=std_logic lab=d23}
C {devices/lab_pin.sym} 4050 -1440 0 0 {name=p25 sig_type=std_logic lab=d24}
C {devices/lab_pin.sym} 4190 -1440 0 0 {name=p26 sig_type=std_logic lab=d25}
C {devices/lab_pin.sym} 4330 -1440 0 0 {name=p27 sig_type=std_logic lab=d26}
C {devices/lab_pin.sym} 4470 -1440 0 0 {name=p28 sig_type=std_logic lab=d27}
C {devices/lab_pin.sym} 4610 -1440 0 0 {name=p29 sig_type=std_logic lab=d28}
C {devices/lab_pin.sym} 4750 -1440 0 0 {name=p30 sig_type=std_logic lab=d29}
C {devices/lab_pin.sym} 4890 -1440 0 0 {name=p31 sig_type=std_logic lab=d30}
C {devices/lab_pin.sym} 5030 -1440 0 0 {name=p32 sig_type=std_logic lab=d31}
C {devices/lab_pin.sym} 690 -1080 3 0 {name=p33 sig_type=std_logic lab=o}
C {devices/lab_pin.sym} 710 -1080 3 0 {name=p34 sig_type=std_logic lab=ob}
C {devices/lab_pin.sym} 730 -1080 3 0 {name=p35 sig_type=std_logic lab=blb}
C {devices/lab_pin.sym} 750 -1080 3 0 {name=p36 sig_type=std_logic lab=b}
C {devices/lab_pin.sym} 770 -1080 3 0 {name=p37 sig_type=std_logic lab=q}
C {devices/lab_pin.sym} 790 -1080 3 0 {name=p38 sig_type=std_logic lab=qb}
