v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
B 2 3380 -3500 4180 -3100 {flags=graph
y1=0
y2=2
ypos1=-0.1
ypos2=1.9
divy=5
subdivy=1
unity=1
x1=2.5e-08
x2=1.25e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
digital=1

color="10 10 10 10 4 4"
node="sel;s0,s1,s2
s
a;a[31],a[30],a[29],a[28],a[27],a[26],a[25],a[24],a[23],a[22],a[21],a[20],a[19],a[18],a[17],a[16],a[15],a[14],a[13],a[12],a[11],a[10],a[9],a[8],a[7],a[6],a[5],a[4],a[3],a[2],a[1],a[0]
o;o[31],o[30],o[29],o[28],o[27],o[26],o[25],o[24],o[23],o[22],o[21],o[20],o[19],o[18],o[17],o[16],o[15],o[14],o[13],o[12],o[11],o[10],o[9],o[8],o[7],o[6],o[5],o[4],o[3],o[2],o[1],o[0]
ssel;s0,s1
stg1;net31,net30,net29,net28,net27,net26,net25,net24,net23,net22,net21,net20,net19,net18,net17,net16,net15,net14,net13,net12,net11,net10,net9,net8,net7,net64,net6,net5,net4,net3,net2,net1"
rainbow=1}
B 2 3380 -3080 4180 -2680 {flags=graph
y1=0
y2=2
ypos1=10.6
ypos2=12.6
divy=5
subdivy=1
unity=1
x1=2.5e-08
x2=1.25e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
digital=1

color="11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 17 18 19 20 21 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 7 8 9"
node="o[31]
o[30]
o[29]
o[28]
o[27]
o[26]
o[25]
o[24]
o[23]
o[22]
o[21]
o[20]
o[19]
o[18]
o[17]
o[16]
o[15]
o[14]
o[13]
o[12]
o[11]
o[10]
o[9]
o[8]
o[7]
o[6]
o[5]
o[4]
o[3]
o[2]
o[1]
o[0]
s
l
net1
net2
net3
net4
net5
net6
net7
net8
net9
net10
net11
net12
net13
net14
net15
net16
net17
net18
net19
net20
net21
net22
net23
net24
net25
net64
net65
net66
net67
net75
net76
net77
net78
net79
net80
net81
net82
net83
net84
net85
net86
net87
net88
net89
net90
net91
net92
net93
net94
net95
net96
"
rainbow=1}
B 2 3380 -3930 4180 -3530 {flags=graph
y1=0
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.5e-08
x2=1.25e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
digital=1

color="11 11"
node="net8
net91"
rainbow=1}
N 1240 -1660 2800 -1660 {
lab=!O[31:0]}
N 1280 -1540 1280 -1480 {
lab=!O[0]}
N 1300 -1540 1300 -1490 {
lab=O[0]}
N 1330 -1540 1330 -1480 {
lab=!O[1]}
N 1350 -1540 1350 -1490 {
lab=O[1]}
N 1380 -1540 1380 -1480 {
lab=!O[2]}
N 1400 -1540 1400 -1490 {
lab=O[2]}
N 1430 -1540 1430 -1480 {
lab=!O[3]}
N 1450 -1540 1450 -1490 {
lab=O[3]}
N 1480 -1540 1480 -1480 {
lab=!O[4]}
N 1500 -1540 1500 -1490 {
lab=O[4]}
N 1530 -1540 1530 -1480 {
lab=!O[5]}
N 1550 -1540 1550 -1490 {
lab=O[5]}
N 1580 -1540 1580 -1480 {
lab=!O[6]}
N 1600 -1540 1600 -1490 {
lab=O[6]}
N 1630 -1540 1630 -1480 {
lab=!O[7]}
N 1650 -1540 1650 -1490 {
lab=O[7]}
N 1680 -1540 1680 -1480 {
lab=!O[8]}
N 1700 -1540 1700 -1490 {
lab=O[8]}
N 1730 -1540 1730 -1480 {
lab=!O[9]}
N 1750 -1540 1750 -1490 {
lab=O[9]}
N 1780 -1540 1780 -1480 {
lab=!O[10]}
N 1800 -1540 1800 -1490 {
lab=O[10]}
N 1830 -1540 1830 -1480 {
lab=!O[11]}
N 1850 -1540 1850 -1490 {
lab=O[11]}
N 1880 -1540 1880 -1480 {
lab=!O[12]}
N 1900 -1540 1900 -1490 {
lab=O[12]}
N 1930 -1540 1930 -1480 {
lab=!O[13]}
N 1950 -1540 1950 -1490 {
lab=O[13]}
N 1980 -1540 1980 -1480 {
lab=!O[14]}
N 2000 -1540 2000 -1490 {
lab=O[14]}
N 2030 -1540 2030 -1480 {
lab=!O[15]}
N 2050 -1540 2050 -1490 {
lab=O[15]}
N 2080 -1540 2080 -1480 {
lab=!O[16]}
N 2100 -1540 2100 -1490 {
lab=O[16]}
N 2130 -1540 2130 -1480 {
lab=!O[17]}
N 2150 -1540 2150 -1490 {
lab=O[17]}
N 2180 -1540 2180 -1480 {
lab=!O[18]}
N 2200 -1540 2200 -1490 {
lab=O[18]}
N 2230 -1540 2230 -1480 {
lab=!O[19]}
N 2250 -1540 2250 -1490 {
lab=O[19]}
N 2280 -1540 2280 -1480 {
lab=!O[20]}
N 2300 -1540 2300 -1490 {
lab=O[20]}
N 2330 -1540 2330 -1480 {
lab=!O[21]}
N 2350 -1540 2350 -1490 {
lab=O[21]}
N 2380 -1540 2380 -1480 {
lab=!O[22]}
N 2400 -1540 2400 -1490 {
lab=O[22]}
N 2430 -1540 2430 -1480 {
lab=!O[23]}
N 2450 -1540 2450 -1490 {
lab=O[23]}
N 2480 -1540 2480 -1480 {
lab=!O[24]}
N 2500 -1540 2500 -1490 {
lab=O[24]}
N 2530 -1540 2530 -1480 {
lab=!O[25]}
N 2550 -1540 2550 -1490 {
lab=O[25]}
N 2580 -1540 2580 -1480 {
lab=!O[26]}
N 2600 -1540 2600 -1490 {
lab=O[26]}
N 2630 -1540 2630 -1480 {
lab=!O[27]}
N 2650 -1540 2650 -1490 {
lab=O[27]}
N 2680 -1540 2680 -1480 {
lab=!O[28]}
N 2700 -1540 2700 -1490 {
lab=O[28]}
N 2730 -1540 2730 -1480 {
lab=!O[29]}
N 2750 -1540 2750 -1490 {
lab=O[29]}
N 2780 -1540 2780 -1480 {
lab=!O[30]}
N 2800 -1540 2800 -1490 {
lab=O[30]}
N 2830 -1540 2830 -1480 {
lab=!O[31]}
N 2850 -1540 2850 -1490 {
lab=O[31]}
N 2800 -1660 2850 -1660 {
lab=!O[31:0]}
N 1300 -1490 1300 -1430 {
lab=O[0]}
N 1350 -1490 1350 -1430 {
lab=O[1]}
N 1400 -1490 1400 -1430 {
lab=O[2]}
N 1450 -1490 1450 -1430 {
lab=O[3]}
N 1500 -1490 1500 -1430 {
lab=O[4]}
N 1550 -1490 1550 -1430 {
lab=O[5]}
N 1600 -1490 1600 -1430 {
lab=O[6]}
N 1650 -1490 1650 -1430 {
lab=O[7]}
N 1700 -1490 1700 -1430 {
lab=O[8]}
N 1750 -1490 1750 -1430 {
lab=O[9]}
N 1800 -1490 1800 -1430 {
lab=O[10]}
N 1850 -1490 1850 -1430 {
lab=O[11]}
N 1900 -1490 1900 -1430 {
lab=O[12]}
N 1950 -1490 1950 -1430 {
lab=O[13]}
N 2000 -1490 2000 -1430 {
lab=O[14]}
N 2050 -1490 2050 -1430 {
lab=O[15]}
N 2100 -1490 2100 -1430 {
lab=O[16]}
N 2150 -1490 2150 -1430 {
lab=O[17]}
N 2200 -1490 2200 -1430 {
lab=O[18]}
N 2250 -1490 2250 -1430 {
lab=O[19]}
N 2300 -1490 2300 -1430 {
lab=O[20]}
N 2350 -1490 2350 -1430 {
lab=O[21]}
N 2400 -1490 2400 -1430 {
lab=O[22]}
N 2450 -1490 2450 -1430 {
lab=O[23]}
N 2500 -1490 2500 -1430 {
lab=O[24]}
N 2550 -1490 2550 -1430 {
lab=O[25]}
N 2600 -1490 2600 -1430 {
lab=O[26]}
N 2650 -1490 2650 -1430 {
lab=O[27]}
N 2700 -1490 2700 -1430 {
lab=O[28]}
N 2750 -1490 2750 -1430 {
lab=O[29]}
N 2800 -1490 2800 -1430 {
lab=O[30]}
N 2850 -1490 2850 -1430 {
lab=O[31]}
N 1240 -1420 2880 -1420 {
bus=true lab=O[31:0]}
N 1240 -1470 2880 -1470 {
bus=true lab=!O[31:0]}
N 2960 -1320 3030 -1320 {
bus=true lab=#net1}
N 2960 -1300 3030 -1300 {
bus=true lab=#net1}
N 3600 -1530 3600 -260 {
bus=true lab=AND[31:0]}
N 3330 -1520 3330 -1320 {
lab=AND[0]}
N 3330 -1520 3430 -1520 {
lab=AND[0]}
N 3330 -1300 3340 -1300 {
lab=AND[1]}
N 3340 -1480 3340 -1300 {
lab=AND[1]}
N 3340 -1480 3430 -1480 {
lab=AND[1]}
N 3350 -1440 3430 -1440 {
lab=AND[2]}
N 3350 -1440 3350 -1280 {
lab=AND[2]}
N 3330 -1280 3350 -1280 {
lab=AND[2]}
N 3360 -1400 3430 -1400 {
lab=AND[3]}
N 3360 -1400 3360 -1260 {
lab=AND[3]}
N 3330 -1260 3360 -1260 {
lab=AND[3]}
N 3370 -1360 3430 -1360 {
lab=AND[4]}
N 3370 -1360 3370 -1240 {
lab=AND[4]}
N 3330 -1240 3370 -1240 {
lab=AND[4]}
N 3380 -1320 3430 -1320 {
lab=AND[5]}
N 3380 -1320 3380 -1220 {
lab=AND[5]}
N 3330 -1220 3380 -1220 {
lab=AND[5]}
N 3390 -1280 3430 -1280 {
lab=AND[6]}
N 3390 -1280 3390 -1200 {
lab=AND[6]}
N 3330 -1200 3390 -1200 {
lab=AND[6]}
N 3430 -1520 3590 -1520 {
lab=AND[0]}
N 3430 -1480 3590 -1480 {
lab=AND[1]}
N 3430 -1440 3590 -1440 {
lab=AND[2]}
N 3430 -1400 3590 -1400 {
lab=AND[3]}
N 3430 -1360 3590 -1360 {
lab=AND[4]}
N 3430 -1320 3590 -1320 {
lab=AND[5]}
N 3430 -1280 3590 -1280 {
lab=AND[6]}
N 3400 -1240 3590 -1240 {
lab=AND[7]}
N 3400 -1240 3400 -1180 {
lab=AND[7]}
N 3330 -1180 3400 -1180 {
lab=AND[7]}
N 3410 -1200 3590 -1200 {
lab=AND[8]}
N 3410 -1200 3410 -1160 {
lab=AND[8]}
N 3330 -1160 3410 -1160 {
lab=AND[8]}
N 3420 -1160 3590 -1160 {
lab=AND[9]}
N 3420 -1160 3420 -1140 {
lab=AND[9]}
N 3330 -1140 3420 -1140 {
lab=AND[9]}
N 3330 -1120 3590 -1120 {
lab=AND[10]}
N 3330 -270 3590 -270 {
lab=AND[31]}
N 3330 -700 3330 -270 {
lab=AND[31]}
N 3340 -310 3590 -310 {
lab=AND[30]}
N 3340 -720 3340 -310 {
lab=AND[30]}
N 3330 -720 3340 -720 {
lab=AND[30]}
N 3350 -360 3590 -360 {
lab=AND[29]}
N 3350 -740 3350 -360 {
lab=AND[29]}
N 3330 -740 3350 -740 {
lab=AND[29]}
N 3360 -400 3590 -400 {
lab=AND[28]}
N 3360 -760 3360 -400 {
lab=AND[28]}
N 3330 -760 3360 -760 {
lab=AND[28]}
N 3370 -440 3590 -440 {
lab=AND[27]}
N 3370 -780 3370 -440 {
lab=AND[27]}
N 3330 -780 3370 -780 {
lab=AND[27]}
N 3380 -480 3590 -480 {
lab=AND[26]}
N 3380 -800 3380 -480 {
lab=AND[26]}
N 3330 -800 3380 -800 {
lab=AND[26]}
N 3390 -520 3590 -520 {
lab=AND[25]}
N 3390 -820 3390 -520 {
lab=AND[25]}
N 3330 -820 3390 -820 {
lab=AND[25]}
N 3400 -560 3590 -560 {
lab=AND[24]}
N 3400 -840 3400 -560 {
lab=AND[24]}
N 3330 -840 3400 -840 {
lab=AND[24]}
N 3410 -600 3590 -600 {
lab=AND[23]}
N 3410 -860 3410 -600 {
lab=AND[23]}
N 3330 -860 3410 -860 {
lab=AND[23]}
N 3420 -640 3590 -640 {
lab=AND[22]}
N 3420 -880 3420 -640 {
lab=AND[22]}
N 3330 -880 3420 -880 {
lab=AND[22]}
N 3430 -680 3590 -680 {
lab=AND[21]}
N 3430 -900 3430 -680 {
lab=AND[21]}
N 3330 -900 3430 -900 {
lab=AND[21]}
N 3440 -720 3590 -720 {
lab=AND[20]}
N 3440 -920 3440 -720 {
lab=AND[20]}
N 3330 -920 3440 -920 {
lab=AND[20]}
N 3450 -760 3590 -760 {
lab=AND[19]}
N 3450 -940 3450 -760 {
lab=AND[19]}
N 3330 -940 3450 -940 {
lab=AND[19]}
N 3460 -800 3590 -800 {
lab=AND[18]}
N 3460 -960 3460 -800 {
lab=AND[18]}
N 3330 -960 3460 -960 {
lab=AND[18]}
N 3470 -840 3590 -840 {
lab=AND[17]}
N 3470 -970 3470 -840 {
lab=AND[17]}
N 3470 -980 3470 -970 {
lab=AND[17]}
N 3330 -980 3470 -980 {
lab=AND[17]}
N 3480 -880 3590 -880 {
lab=AND[16]}
N 3480 -1000 3480 -880 {
lab=AND[16]}
N 3330 -1000 3480 -1000 {
lab=AND[16]}
N 3490 -920 3590 -920 {
lab=AND[15]}
N 3490 -1020 3490 -920 {
lab=AND[15]}
N 3330 -1020 3490 -1020 {
lab=AND[15]}
N 3500 -960 3590 -960 {
lab=AND[14]}
N 3500 -1040 3500 -960 {
lab=AND[14]}
N 3330 -1040 3500 -1040 {
lab=AND[14]}
N 3510 -1000 3590 -1000 {
lab=AND[13]}
N 3510 -1060 3510 -1000 {
lab=AND[13]}
N 3330 -1060 3510 -1060 {
lab=AND[13]}
N 3520 -1040 3590 -1040 {
lab=AND[12]}
N 3520 -1080 3520 -1040 {
lab=AND[12]}
N 3330 -1080 3520 -1080 {
lab=AND[12]}
N 3330 -1100 3530 -1100 {
lab=AND[11]}
N 3530 -1100 3530 -1080 {
lab=AND[11]}
N 3530 -1080 3590 -1080 {
lab=AND[11]}
C {1 bit 6-T SRAM.sym} 1290 -1600 1 0 {name=x1}
C {1 bit 6-T SRAM.sym} 1340 -1600 1 0 {name=x2}
C {1 bit 6-T SRAM.sym} 1390 -1600 1 0 {name=x3}
C {1 bit 6-T SRAM.sym} 1440 -1600 1 0 {name=x4}
C {1 bit 6-T SRAM.sym} 1490 -1600 1 0 {name=x5}
C {1 bit 6-T SRAM.sym} 1540 -1600 1 0 {name=x6}
C {1 bit 6-T SRAM.sym} 1590 -1600 1 0 {name=x7}
C {1 bit 6-T SRAM.sym} 1640 -1600 1 0 {name=x8}
C {1 bit 6-T SRAM.sym} 1690 -1600 1 0 {name=x9}
C {1 bit 6-T SRAM.sym} 1740 -1600 1 0 {name=x10}
C {1 bit 6-T SRAM.sym} 1790 -1600 1 0 {name=x11}
C {1 bit 6-T SRAM.sym} 1840 -1600 1 0 {name=x12}
C {1 bit 6-T SRAM.sym} 1890 -1600 1 0 {name=x13}
C {1 bit 6-T SRAM.sym} 1940 -1600 1 0 {name=x14}
C {1 bit 6-T SRAM.sym} 1990 -1600 1 0 {name=x15}
C {1 bit 6-T SRAM.sym} 2040 -1600 1 0 {name=x16}
C {1 bit 6-T SRAM.sym} 2090 -1600 1 0 {name=x17}
C {1 bit 6-T SRAM.sym} 2140 -1600 1 0 {name=x18}
C {1 bit 6-T SRAM.sym} 2190 -1600 1 0 {name=x19}
C {1 bit 6-T SRAM.sym} 2240 -1600 1 0 {name=x20}
C {1 bit 6-T SRAM.sym} 2290 -1600 1 0 {name=x21}
C {1 bit 6-T SRAM.sym} 2340 -1600 1 0 {name=x22}
C {1 bit 6-T SRAM.sym} 2390 -1600 1 0 {name=x23}
C {1 bit 6-T SRAM.sym} 2440 -1600 1 0 {name=x24}
C {1 bit 6-T SRAM.sym} 2490 -1600 1 0 {name=x25}
C {1 bit 6-T SRAM.sym} 2540 -1600 1 0 {name=x26}
C {1 bit 6-T SRAM.sym} 2590 -1600 1 0 {name=x27}
C {1 bit 6-T SRAM.sym} 2640 -1600 1 0 {name=x28}
C {1 bit 6-T SRAM.sym} 2690 -1600 1 0 {name=x29}
C {1 bit 6-T SRAM.sym} 2740 -1600 1 0 {name=x30}
C {1 bit 6-T SRAM.sym} 2790 -1600 1 0 {name=x31}
C {devices/bus_tap.sym} 1290 -1470 3 0 {name=l33 lab=[0]}
C {devices/bus_tap.sym} 1340 -1470 3 0 {name=l34 lab=[1]}
C {devices/bus_tap.sym} 1390 -1470 3 0 {name=l35 lab=[2]}
C {devices/bus_tap.sym} 1440 -1470 3 0 {name=l36 lab=[3]}
C {devices/bus_tap.sym} 1490 -1470 3 0 {name=l37 lab=[4]}
C {devices/bus_tap.sym} 1540 -1470 3 0 {name=l38 lab=[5]}
C {devices/bus_tap.sym} 1590 -1470 3 0 {name=l39 lab=[6]}
C {devices/bus_tap.sym} 1640 -1470 3 0 {name=l40 lab=[7]}
C {devices/bus_tap.sym} 1690 -1470 3 0 {name=l41 lab=[8]}
C {devices/bus_tap.sym} 1740 -1470 3 0 {name=l42 lab=[9]}
C {devices/bus_tap.sym} 1790 -1470 3 0 {name=l43 lab=[10]}
C {devices/bus_tap.sym} 1840 -1470 3 0 {name=l44 lab=[11]}
C {devices/bus_tap.sym} 1890 -1470 3 0 {name=l45 lab=[12]}
C {devices/bus_tap.sym} 1940 -1470 3 0 {name=l46 lab=[13]}
C {devices/bus_tap.sym} 1990 -1470 3 0 {name=l47 lab=[14]}
C {devices/bus_tap.sym} 2040 -1470 3 0 {name=l48 lab=[15]}
C {devices/bus_tap.sym} 2090 -1470 3 0 {name=l49 lab=[16]}
C {devices/bus_tap.sym} 2140 -1470 3 0 {name=l50 lab=[17]}
C {devices/bus_tap.sym} 2190 -1470 3 0 {name=l51 lab=[18]}
C {devices/bus_tap.sym} 2240 -1470 3 0 {name=l52 lab=[19]}
C {devices/bus_tap.sym} 2290 -1470 3 0 {name=l53 lab=[20]}
C {devices/bus_tap.sym} 2340 -1470 3 0 {name=l54 lab=[21]}
C {devices/bus_tap.sym} 2390 -1470 3 0 {name=l55 lab=[22]}
C {devices/bus_tap.sym} 2440 -1470 3 0 {name=l56 lab=[23]}
C {devices/bus_tap.sym} 2490 -1470 3 0 {name=l57 lab=[24]}
C {devices/bus_tap.sym} 2540 -1470 3 0 {name=l58 lab=[25]}
C {devices/bus_tap.sym} 2590 -1470 3 0 {name=l59 lab=[26]}
C {devices/bus_tap.sym} 2640 -1470 3 0 {name=l60 lab=[27]}
C {devices/bus_tap.sym} 2690 -1470 3 0 {name=l61 lab=[28]}
C {devices/bus_tap.sym} 2740 -1470 3 0 {name=l62 lab=[29]}
C {devices/bus_tap.sym} 2790 -1470 3 0 {name=l63 lab=[30]}
C {devices/bus_tap.sym} 2840 -1470 3 0 {name=l64 lab=[31]}
C {devices/opin.sym} 2880 -1420 0 0 {name=p10 sig_type=std_logic lab=O[31:0]}
C {1 bit 6-T SRAM.sym} 2840 -1600 1 0 {name=x32}
C {devices/bus_tap.sym} 1310 -1420 3 0 {name=l1 lab=[0]}
C {devices/bus_tap.sym} 1360 -1420 3 0 {name=l2 lab=[1]}
C {devices/bus_tap.sym} 1410 -1420 3 0 {name=l3 lab=[2]}
C {devices/bus_tap.sym} 1460 -1420 3 0 {name=l4 lab=[3]}
C {devices/bus_tap.sym} 1510 -1420 3 0 {name=l5 lab=[4]}
C {devices/bus_tap.sym} 1560 -1420 3 0 {name=l6 lab=[5]}
C {devices/bus_tap.sym} 1610 -1420 3 0 {name=l7 lab=[6]}
C {devices/bus_tap.sym} 1660 -1420 3 0 {name=l8 lab=[7]}
C {devices/bus_tap.sym} 1710 -1420 3 0 {name=l9 lab=[8]}
C {devices/bus_tap.sym} 1760 -1420 3 0 {name=l10 lab=[9]}
C {devices/bus_tap.sym} 1810 -1420 3 0 {name=l11 lab=[10]}
C {devices/bus_tap.sym} 1860 -1420 3 0 {name=l12 lab=[11]}
C {devices/bus_tap.sym} 1910 -1420 3 0 {name=l13 lab=[12]}
C {devices/bus_tap.sym} 1960 -1420 3 0 {name=l14 lab=[13]}
C {devices/bus_tap.sym} 2010 -1420 3 0 {name=l15 lab=[14]}
C {devices/bus_tap.sym} 2060 -1420 3 0 {name=l16 lab=[15]}
C {devices/bus_tap.sym} 2110 -1420 3 0 {name=l17 lab=[16]}
C {devices/bus_tap.sym} 2160 -1420 3 0 {name=l18 lab=[17]}
C {devices/bus_tap.sym} 2210 -1420 3 0 {name=l19 lab=[18]}
C {devices/bus_tap.sym} 2260 -1420 3 0 {name=l20 lab=[19]}
C {devices/bus_tap.sym} 2310 -1420 3 0 {name=l21 lab=[20]}
C {devices/bus_tap.sym} 2360 -1420 3 0 {name=l22 lab=[21]}
C {devices/bus_tap.sym} 2410 -1420 3 0 {name=l23 lab=[22]}
C {devices/bus_tap.sym} 2460 -1420 3 0 {name=l24 lab=[23]}
C {devices/bus_tap.sym} 2510 -1420 3 0 {name=l25 lab=[24]}
C {devices/bus_tap.sym} 2560 -1420 3 0 {name=l26 lab=[25]}
C {devices/bus_tap.sym} 2610 -1420 3 0 {name=l27 lab=[26]}
C {devices/bus_tap.sym} 2660 -1420 3 0 {name=l28 lab=[27]}
C {devices/bus_tap.sym} 2710 -1420 3 0 {name=l29 lab=[28]}
C {devices/bus_tap.sym} 2760 -1420 3 0 {name=l30 lab=[29]}
C {devices/bus_tap.sym} 2810 -1420 3 0 {name=l31 lab=[30]}
C {devices/bus_tap.sym} 2860 -1420 3 0 {name=l32 lab=[31]}
C {devices/opin.sym} 2880 -1470 0 0 {name=p1 sig_type=std_logic lab=!O[31:0]}
C {devices/ipin.sym} 1240 -1660 0 0 {name=p2 sig_type=std_logic lab=wl}
C {devices/vsource.sym} 5280 -2520 0 0 {name=VB1 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 5280 -2550 0 0 {name=VB2 sig_type=std_logic lab=A[3]}
C {devices/gnd.sym} 5280 -2490 0 0 {name=l65 lab=GND}
C {devices/vsource.sym} 4720 -2510 0 0 {name=VB3 value="pwl=0 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 4720 -2540 0 0 {name=VB4 sig_type=std_logic lab=A[1]}
C {devices/gnd.sym} 4720 -2480 0 0 {name=l66 lab=GND}
C {devices/vsource.sym} 4510 -2530 0 0 {name=VB5 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 4510 -2560 0 0 {name=VB6 sig_type=std_logic lab=A[0]}
C {devices/gnd.sym} 4510 -2500 0 0 {name=l67 lab=GND}
C {devices/vsource.sym} 4960 -2530 0 0 {name=VB7 value="pwl=0 1.8 100n 1.8 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 4960 -2560 0 0 {name=VB8 sig_type=std_logic lab=A[2]}
C {devices/gnd.sym} 4960 -2500 0 0 {name=l68 lab=GND}
C {devices/vsource.sym} 5280 -2720 0 0 {name=VB9 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 5280 -2750 0 0 {name=VB10 sig_type=std_logic lab=A[7]}
C {devices/gnd.sym} 5280 -2690 0 0 {name=l69 lab=GND}
C {devices/vsource.sym} 4720 -2710 0 0 {name=VB11 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 4720 -2740 0 0 {name=VB12 sig_type=std_logic lab=A[5]}
C {devices/gnd.sym} 4720 -2680 0 0 {name=l70 lab=GND}
C {devices/vsource.sym} 4550 -2730 0 0 {name=VB13 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 4550 -2760 0 0 {name=VB14 sig_type=std_logic lab=A[4]}
C {devices/gnd.sym} 4550 -2700 0 0 {name=l71 lab=GND}
C {devices/vsource.sym} 4960 -2730 0 0 {name=VB15 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 4960 -2760 0 0 {name=VB16 sig_type=std_logic lab=A[6]}
C {devices/gnd.sym} 4960 -2700 0 0 {name=l72 lab=GND}
C {devices/vsource.sym} 5280 -2920 0 0 {name=VB17 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 5280 -2950 0 0 {name=VB18 sig_type=std_logic lab=A[13]}
C {devices/gnd.sym} 5280 -2890 0 0 {name=l73 lab=GND}
C {devices/vsource.sym} 4720 -2910 0 0 {name=VB19 value="pwl=0 1.8 100n 1.8 " savecurrent=false}
C {devices/lab_pin.sym} 4720 -2940 0 0 {name=VB20 sig_type=std_logic lab=A[11]}
C {devices/gnd.sym} 4720 -2880 0 0 {name=l74 lab=GND}
C {devices/vsource.sym} 4550 -2930 0 0 {name=VB21 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 4550 -2960 0 0 {name=VB22 sig_type=std_logic lab=A[10]}
C {devices/gnd.sym} 4550 -2900 0 0 {name=l75 lab=GND}
C {devices/vsource.sym} 4960 -2930 0 0 {name=VB23 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 4960 -2960 0 0 {name=VB24 sig_type=std_logic lab=A[12]}
C {devices/gnd.sym} 4960 -2900 0 0 {name=l76 lab=GND}
C {devices/vsource.sym} 5280 -3120 0 0 {name=VB25 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 5280 -3150 0 0 {name=VB26 sig_type=std_logic lab=A[9]}
C {devices/gnd.sym} 5280 -3090 0 0 {name=l77 lab=GND}
C {devices/vsource.sym} 4720 -3110 0 0 {name=VB27 value="pwl=0 0 100n 0 " savecurrent=false}
C {devices/lab_pin.sym} 4720 -3140 0 0 {name=VB28 sig_type=std_logic lab=A[15]}
C {devices/gnd.sym} 4720 -3080 0 0 {name=l78 lab=GND}
C {devices/vsource.sym} 4550 -3130 0 0 {name=VB29 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 4550 -3160 0 0 {name=VB30 sig_type=std_logic lab=A[14]}
C {devices/gnd.sym} 4550 -3100 0 0 {name=l79 lab=GND}
C {devices/vsource.sym} 4960 -3130 0 0 {name=VB31 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 4960 -3160 0 0 {name=VB32 sig_type=std_logic lab=A[8]}
C {devices/gnd.sym} 4960 -3100 0 0 {name=l80 lab=GND}
C {devices/vsource.sym} 4760 -3570 0 0 {name=VA19 value="pwl=0 0 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 4760 -3600 0 0 {name=p22 sig_type=std_logic lab=A[23]}
C {devices/vsource.sym} 4760 -3470 0 0 {name=VA20 value="pwl=0 1.8 50n 1.8 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 4760 -3500 0 0 {name=p23 sig_type=std_logic lab=A[22]}
C {devices/vsource.sym} 4760 -3370 0 0 {name=VA21 value="pwl=0 1.8 50n 1.8 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 4760 -3400 0 0 {name=p24 sig_type=std_logic lab=A[21]}
C {devices/vsource.sym} 4760 -3270 0 0 {name=VA22 value="pwl=0 1.8 50n 1.8 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 4760 -3300 0 0 {name=VA23 sig_type=std_logic lab=A[20]}
C {devices/gnd.sym} 4760 -3240 0 0 {name=l91 lab=GND}
C {devices/gnd.sym} 4760 -3340 0 0 {name=l93 lab=GND}
C {devices/gnd.sym} 4760 -3440 0 0 {name=l95 lab=GND}
C {devices/gnd.sym} 4760 -3540 0 0 {name=l98 lab=GND}
C {devices/vsource.sym} 5180 -3540 0 0 {name=VA24 value="pwl=0 0 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 5180 -3570 0 0 {name=p25 sig_type=std_logic lab=A[17]}
C {devices/vsource.sym} 5180 -3440 0 0 {name=VA25 value="pwl=0 1.8 50n 1.8 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 5180 -3470 0 0 {name=p26 sig_type=std_logic lab=A[16]}
C {devices/gnd.sym} 5180 -3410 0 0 {name=l103 lab=GND}
C {devices/gnd.sym} 5180 -3510 0 0 {name=l106 lab=GND}
C {devices/vsource.sym} 4761.46728515625 -3688.88671875 0 0 {name=VA29 value="pwl=0 1.8 50n 1.8 50n 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 4761.46728515625 -3718.88671875 0 0 {name=p28 sig_type=std_logic lab=A[28]}
C {devices/gnd.sym} 4761.46728515625 -3658.88671875 0 0 {name=l107 lab=GND}
C {devices/vsource.sym} 5181.46728515625 -3668.88671875 0 0 {name=VA30 value="pwl=0 1.8 50n 1.8 50n 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 5181.46728515625 -3698.88671875 0 0 {name=p29 sig_type=std_logic lab=A[18]}
C {devices/gnd.sym} 5181.46728515625 -3638.88671875 0 0 {name=l108 lab=GND}
C {devices/vsource.sym} 4761.46728515625 -3838.88671875 0 0 {name=VA31 value="pwl=0 1.8 50n 1.8 50n 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 4761.46728515625 -3868.88671875 0 0 {name=p30 sig_type=std_logic lab=A[29]}
C {devices/gnd.sym} 4761.46728515625 -3808.88671875 0 0 {name=l109 lab=GND}
C {devices/vsource.sym} 5171.46728515625 -3808.88671875 0 0 {name=VA32 value="pwl=0 1.8 50n 1.8 50n 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 5171.46728515625 -3838.88671875 0 0 {name=p31 sig_type=std_logic lab=A[30]}
C {devices/gnd.sym} 5171.46728515625 -3778.88671875 0 0 {name=l110 lab=GND}
C {devices/vsource.sym} 4951.46728515625 -3348.88671875 0 0 {name=VA38 value="pwl=0 1.8 50n 1.8 50n 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 4951.46728515625 -3378.88671875 0 0 {name=p36 sig_type=std_logic lab=A[19]}
C {devices/gnd.sym} 4951.46728515625 -3318.88671875 0 0 {name=l117 lab=GND}
C {devices/vsource.sym} 5480 -3630 0 0 {name=VA39 value="pwl=0 0 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 5480 -3660 0 0 {name=p37 sig_type=std_logic lab=A[27]}
C {devices/vsource.sym} 5480 -3530 0 0 {name=VA40 value="pwl=0 1.8 50n 1.8 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 5480 -3560 0 0 {name=p38 sig_type=std_logic lab=A[26]}
C {devices/vsource.sym} 5480 -3430 0 0 {name=VA41 value="pwl=0 1.8 50n 1.8 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 5480 -3460 0 0 {name=p39 sig_type=std_logic lab=A[25]}
C {devices/vsource.sym} 5480 -3330 0 0 {name=VA42 value="pwl=0 1.8 50n 1.8 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 5480 -3360 0 0 {name=VA43 sig_type=std_logic lab=A[24]}
C {devices/gnd.sym} 5480 -3300 0 0 {name=l118 lab=GND}
C {devices/gnd.sym} 5480 -3400 0 0 {name=l119 lab=GND}
C {devices/gnd.sym} 5480 -3500 0 0 {name=l120 lab=GND}
C {devices/gnd.sym} 5480 -3600 0 0 {name=l121 lab=GND}
C {devices/vsource.sym} 5441.46728515625 -3728.88671875 0 0 {name=VA44 value="pwl=0 1.8 50n 1.8 50n 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 5441.46728515625 -3758.88671875 0 0 {name=p40 sig_type=std_logic lab=A[31]}
C {devices/gnd.sym} 5441.46728515625 -3698.88671875 0 0 {name=l122 lab=GND}
C {devices/vsource.sym} 6011.46728515625 -2518.88671875 0 0 {name=VDD value=1.8 savecurrent=false}
C {devices/lab_pin.sym} 6011.46728515625 -2548.88671875 0 0 {name=VDD1 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 6011.46728515625 -2488.88671875 0 0 {name=VDD2 lab=GND}
C {devices/code_shown.sym} 6100 -2645 0 0 {name=S1 only_toplevel=false value=".tran 0.01n 300n
.save all"}
C {sky130_fd_pr/corner.sym} 6085 -2575 0 0 {name=CORNER only_toplevel=true corner=tt}
C {devices/vsource.sym} 3850 -2440 0 0 {name=VA17 value="pwl=0 1.8 100n 1.8 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 3850 -2470 0 0 {name=p27 sig_type=std_logic lab=S}
C {devices/vsource.sym} 3850 -2340 0 0 {name=VA18 value="pwl=0 1.8 50n 1.8 50n 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 3850 -2370 0 0 {name=p46 sig_type=std_logic lab=S0}
C {devices/vsource.sym} 3850 -2240 0 0 {name=VA26 value="pwl=0 1.8 50n 1.8 50n 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 3850 -2270 0 0 {name=VA27 sig_type=std_logic lab=S1}
C {devices/gnd.sym} 3850 -2210 0 0 {name=l81 lab=GND}
C {devices/gnd.sym} 3850 -2310 0 0 {name=l82 lab=GND}
C {devices/gnd.sym} 3850 -2410 0 0 {name=l83 lab=GND}
C {devices/vsource.sym} 4240 -2240 0 0 {name=VA1 value="pwl=0 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 4240 -2270 0 0 {name=VA2 sig_type=std_logic lab=l}
C {devices/gnd.sym} 4240 -2210 0 0 {name=l84 lab=GND}
C {devices/vsource.sym} 3850 -2130 0 0 {name=VA3 value="pwl=0 1.8 50n 1.8 50n 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 3850 -2160 0 0 {name=VA4 sig_type=std_logic lab=S2}
C {devices/gnd.sym} 3850 -2100 0 0 {name=l85 lab=GND}
C {devices/vsource.sym} 3850 -2030 0 0 {name=VA5 value="pwl=0 1.8 50n 1.8 50n 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 3850 -2060 0 0 {name=VA6 sig_type=std_logic lab=S3}
C {devices/gnd.sym} 3850 -2000 0 0 {name=l86 lab=GND}
C {devices/ipin.sym} 2960 -1320 0 0 {name=p3 sig_type=std_logic lab=B[31:0]}
C {devices/ipin.sym} 2960 -1300 0 0 {name=p4 sig_type=std_logic lab=A[31:0]}
C {32bit_AND.sym} 3180 -1010 0 0 {name=x34}
C {devices/bus_tap.sym} 3600 -1510 0 1 {name=l161 lab=[0]}
C {devices/bus_tap.sym} 3600 -1470 0 1 {name=l162 lab=[1]}
C {devices/bus_tap.sym} 3600 -1430 0 1 {name=l163 lab=[2]}
C {devices/bus_tap.sym} 3600 -1390 0 1 {name=l164 lab=[3]}
C {devices/bus_tap.sym} 3600 -1350 0 1 {name=l165 lab=[4]}
C {devices/bus_tap.sym} 3600 -1310 0 1 {name=l166 lab=[5]}
C {devices/bus_tap.sym} 3600 -1270 0 1 {name=l167 lab=[6]}
C {devices/bus_tap.sym} 3600 -1230 0 1 {name=l168 lab=[7]}
C {devices/bus_tap.sym} 3600 -1190 0 1 {name=l169 lab=[8]}
C {devices/bus_tap.sym} 3600 -1150 0 1 {name=l170 lab=[9]}
C {devices/bus_tap.sym} 3600 -1110 0 1 {name=l171 lab=[10]}
C {devices/bus_tap.sym} 3600 -1070 0 1 {name=l172 lab=[11]}
C {devices/bus_tap.sym} 3600 -1030 0 1 {name=l173 lab=[12]}
C {devices/bus_tap.sym} 3600 -990 0 1 {name=l174 lab=[13]}
C {devices/bus_tap.sym} 3600 -950 0 1 {name=l175 lab=[14]}
C {devices/bus_tap.sym} 3600 -910 0 1 {name=l176 lab=[15]}
C {devices/bus_tap.sym} 3600 -870 0 1 {name=l177 lab=[16]}
C {devices/bus_tap.sym} 3600 -830 0 1 {name=l178 lab=[17]}
C {devices/bus_tap.sym} 3600 -790 0 1 {name=l179 lab=[18]}
C {devices/bus_tap.sym} 3600 -750 0 1 {name=l180 lab=[19]}
C {devices/bus_tap.sym} 3600 -710 0 1 {name=l181 lab=[20]}
C {devices/bus_tap.sym} 3600 -670 0 1 {name=l182 lab=[21]}
C {devices/bus_tap.sym} 3600 -630 0 1 {name=l183 lab=[22]}
C {devices/bus_tap.sym} 3600 -590 0 1 {name=l184 lab=[23]}
C {devices/bus_tap.sym} 3600 -550 0 1 {name=l185 lab=[24]}
C {devices/bus_tap.sym} 3600 -510 0 1 {name=l186 lab=[25]}
C {devices/bus_tap.sym} 3600 -470 0 1 {name=l187 lab=[26]}
C {devices/bus_tap.sym} 3600 -430 0 1 {name=l188 lab=[27]}
C {devices/bus_tap.sym} 3600 -390 0 1 {name=l189 lab=[28]}
C {devices/bus_tap.sym} 3600 -350 0 1 {name=l190 lab=[29]}
C {devices/bus_tap.sym} 3600 -300 0 1 {name=l191 lab=[30]}
C {devices/bus_tap.sym} 3600 -260 0 1 {name=l192 lab=[31]}
C {devices/ipin.sym} 3600 -1530 1 0 {name=p5 sig_type=std_logic lab=AND[31:0]}
