v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 1240 -1660 2800 -1660 {
lab=!O[31:0]}
N 1280 -1540 1280 -1480 {
lab=!O[0]}
N 1300 -1540 1300 -1490 {
lab=O[0]}
N 1330 -1540 1330 -1480 {
lab=!O[1]}
N 1350 -1540 1350 -1490 {
lab=O[1]}
N 1380 -1540 1380 -1480 {
lab=!O[2]}
N 1400 -1540 1400 -1490 {
lab=O[2]}
N 1430 -1540 1430 -1480 {
lab=!O[3]}
N 1450 -1540 1450 -1490 {
lab=O[3]}
N 1480 -1540 1480 -1480 {
lab=!O[4]}
N 1500 -1540 1500 -1490 {
lab=O[4]}
N 1530 -1540 1530 -1480 {
lab=!O[5]}
N 1550 -1540 1550 -1490 {
lab=O[5]}
N 1580 -1540 1580 -1480 {
lab=!O[6]}
N 1600 -1540 1600 -1490 {
lab=O[6]}
N 1630 -1540 1630 -1480 {
lab=!O[7]}
N 1650 -1540 1650 -1490 {
lab=O[7]}
N 1680 -1540 1680 -1480 {
lab=!O[8]}
N 1700 -1540 1700 -1490 {
lab=O[8]}
N 1730 -1540 1730 -1480 {
lab=!O[9]}
N 1750 -1540 1750 -1490 {
lab=O[9]}
N 1780 -1540 1780 -1480 {
lab=!O[10]}
N 1800 -1540 1800 -1490 {
lab=O[10]}
N 1830 -1540 1830 -1480 {
lab=!O[11]}
N 1850 -1540 1850 -1490 {
lab=O[11]}
N 1880 -1540 1880 -1480 {
lab=!O[12]}
N 1900 -1540 1900 -1490 {
lab=O[12]}
N 1930 -1540 1930 -1480 {
lab=!O[13]}
N 1950 -1540 1950 -1490 {
lab=O[13]}
N 1980 -1540 1980 -1480 {
lab=!O[14]}
N 2000 -1540 2000 -1490 {
lab=O[14]}
N 2030 -1540 2030 -1480 {
lab=!O[15]}
N 2050 -1540 2050 -1490 {
lab=O[15]}
N 2080 -1540 2080 -1480 {
lab=!O[16]}
N 2100 -1540 2100 -1490 {
lab=O[16]}
N 2130 -1540 2130 -1480 {
lab=!O[17]}
N 2150 -1540 2150 -1490 {
lab=O[17]}
N 2180 -1540 2180 -1480 {
lab=!O[18]}
N 2200 -1540 2200 -1490 {
lab=O[18]}
N 2230 -1540 2230 -1480 {
lab=!O[19]}
N 2250 -1540 2250 -1490 {
lab=O[19]}
N 2280 -1540 2280 -1480 {
lab=!O[20]}
N 2300 -1540 2300 -1490 {
lab=O[20]}
N 2330 -1540 2330 -1480 {
lab=!O[21]}
N 2350 -1540 2350 -1490 {
lab=O[21]}
N 2380 -1540 2380 -1480 {
lab=!O[22]}
N 2400 -1540 2400 -1490 {
lab=O[22]}
N 2430 -1540 2430 -1480 {
lab=!O[23]}
N 2450 -1540 2450 -1490 {
lab=O[23]}
N 2480 -1540 2480 -1480 {
lab=!O[24]}
N 2500 -1540 2500 -1490 {
lab=O[24]}
N 2530 -1540 2530 -1480 {
lab=!O[25]}
N 2550 -1540 2550 -1490 {
lab=O[25]}
N 2580 -1540 2580 -1480 {
lab=!O[26]}
N 2600 -1540 2600 -1490 {
lab=O[26]}
N 2630 -1540 2630 -1480 {
lab=!O[27]}
N 2650 -1540 2650 -1490 {
lab=O[27]}
N 2680 -1540 2680 -1480 {
lab=!O[28]}
N 2700 -1540 2700 -1490 {
lab=O[28]}
N 2730 -1540 2730 -1480 {
lab=!O[29]}
N 2750 -1540 2750 -1490 {
lab=O[29]}
N 2780 -1540 2780 -1480 {
lab=!O[30]}
N 2800 -1540 2800 -1490 {
lab=O[30]}
N 2830 -1540 2830 -1480 {
lab=!O[31]}
N 2850 -1540 2850 -1490 {
lab=O[31]}
N 2800 -1660 2850 -1660 {
lab=!O[31:0]}
N 1300 -1490 1300 -1430 {
lab=O[0]}
N 1350 -1490 1350 -1430 {
lab=O[1]}
N 1400 -1490 1400 -1430 {
lab=O[2]}
N 1450 -1490 1450 -1430 {
lab=O[3]}
N 1500 -1490 1500 -1430 {
lab=O[4]}
N 1550 -1490 1550 -1430 {
lab=O[5]}
N 1600 -1490 1600 -1430 {
lab=O[6]}
N 1650 -1490 1650 -1430 {
lab=O[7]}
N 1700 -1490 1700 -1430 {
lab=O[8]}
N 1750 -1490 1750 -1430 {
lab=O[9]}
N 1800 -1490 1800 -1430 {
lab=O[10]}
N 1850 -1490 1850 -1430 {
lab=O[11]}
N 1900 -1490 1900 -1430 {
lab=O[12]}
N 1950 -1490 1950 -1430 {
lab=O[13]}
N 2000 -1490 2000 -1430 {
lab=O[14]}
N 2050 -1490 2050 -1430 {
lab=O[15]}
N 2100 -1490 2100 -1430 {
lab=O[16]}
N 2150 -1490 2150 -1430 {
lab=O[17]}
N 2200 -1490 2200 -1430 {
lab=O[18]}
N 2250 -1490 2250 -1430 {
lab=O[19]}
N 2300 -1490 2300 -1430 {
lab=O[20]}
N 2350 -1490 2350 -1430 {
lab=O[21]}
N 2400 -1490 2400 -1430 {
lab=O[22]}
N 2450 -1490 2450 -1430 {
lab=O[23]}
N 2500 -1490 2500 -1430 {
lab=O[24]}
N 2550 -1490 2550 -1430 {
lab=O[25]}
N 2600 -1490 2600 -1430 {
lab=O[26]}
N 2650 -1490 2650 -1430 {
lab=O[27]}
N 2700 -1490 2700 -1430 {
lab=O[28]}
N 2750 -1490 2750 -1430 {
lab=O[29]}
N 2800 -1490 2800 -1430 {
lab=O[30]}
N 2850 -1490 2850 -1430 {
lab=O[31]}
N 1240 -1420 2880 -1420 {
bus=true lab=O[31:0]}
N 1240 -1470 2880 -1470 {
bus=true lab=!O[31:0]}
C {1 bit 6-T SRAM.sym} 1290 -1600 1 0 {name=x1}
C {1 bit 6-T SRAM.sym} 1340 -1600 1 0 {name=x2}
C {1 bit 6-T SRAM.sym} 1390 -1600 1 0 {name=x3}
C {1 bit 6-T SRAM.sym} 1440 -1600 1 0 {name=x4}
C {1 bit 6-T SRAM.sym} 1490 -1600 1 0 {name=x5}
C {1 bit 6-T SRAM.sym} 1540 -1600 1 0 {name=x6}
C {1 bit 6-T SRAM.sym} 1590 -1600 1 0 {name=x7}
C {1 bit 6-T SRAM.sym} 1640 -1600 1 0 {name=x8}
C {1 bit 6-T SRAM.sym} 1690 -1600 1 0 {name=x9}
C {1 bit 6-T SRAM.sym} 1740 -1600 1 0 {name=x10}
C {1 bit 6-T SRAM.sym} 1790 -1600 1 0 {name=x11}
C {1 bit 6-T SRAM.sym} 1840 -1600 1 0 {name=x12}
C {1 bit 6-T SRAM.sym} 1890 -1600 1 0 {name=x13}
C {1 bit 6-T SRAM.sym} 1940 -1600 1 0 {name=x14}
C {1 bit 6-T SRAM.sym} 1990 -1600 1 0 {name=x15}
C {1 bit 6-T SRAM.sym} 2040 -1600 1 0 {name=x16}
C {1 bit 6-T SRAM.sym} 2090 -1600 1 0 {name=x17}
C {1 bit 6-T SRAM.sym} 2140 -1600 1 0 {name=x18}
C {1 bit 6-T SRAM.sym} 2190 -1600 1 0 {name=x19}
C {1 bit 6-T SRAM.sym} 2240 -1600 1 0 {name=x20}
C {1 bit 6-T SRAM.sym} 2290 -1600 1 0 {name=x21}
C {1 bit 6-T SRAM.sym} 2340 -1600 1 0 {name=x22}
C {1 bit 6-T SRAM.sym} 2390 -1600 1 0 {name=x23}
C {1 bit 6-T SRAM.sym} 2440 -1600 1 0 {name=x24}
C {1 bit 6-T SRAM.sym} 2490 -1600 1 0 {name=x25}
C {1 bit 6-T SRAM.sym} 2540 -1600 1 0 {name=x26}
C {1 bit 6-T SRAM.sym} 2590 -1600 1 0 {name=x27}
C {1 bit 6-T SRAM.sym} 2640 -1600 1 0 {name=x28}
C {1 bit 6-T SRAM.sym} 2690 -1600 1 0 {name=x29}
C {1 bit 6-T SRAM.sym} 2740 -1600 1 0 {name=x30}
C {1 bit 6-T SRAM.sym} 2790 -1600 1 0 {name=x31}
C {devices/bus_tap.sym} 1290 -1470 3 0 {name=l33 lab=[0]}
C {devices/bus_tap.sym} 1340 -1470 3 0 {name=l34 lab=[1]}
C {devices/bus_tap.sym} 1390 -1470 3 0 {name=l35 lab=[2]}
C {devices/bus_tap.sym} 1440 -1470 3 0 {name=l36 lab=[3]}
C {devices/bus_tap.sym} 1490 -1470 3 0 {name=l37 lab=[4]}
C {devices/bus_tap.sym} 1540 -1470 3 0 {name=l38 lab=[5]}
C {devices/bus_tap.sym} 1590 -1470 3 0 {name=l39 lab=[6]}
C {devices/bus_tap.sym} 1640 -1470 3 0 {name=l40 lab=[7]}
C {devices/bus_tap.sym} 1690 -1470 3 0 {name=l41 lab=[8]}
C {devices/bus_tap.sym} 1740 -1470 3 0 {name=l42 lab=[9]}
C {devices/bus_tap.sym} 1790 -1470 3 0 {name=l43 lab=[10]}
C {devices/bus_tap.sym} 1840 -1470 3 0 {name=l44 lab=[11]}
C {devices/bus_tap.sym} 1890 -1470 3 0 {name=l45 lab=[12]}
C {devices/bus_tap.sym} 1940 -1470 3 0 {name=l46 lab=[13]}
C {devices/bus_tap.sym} 1990 -1470 3 0 {name=l47 lab=[14]}
C {devices/bus_tap.sym} 2040 -1470 3 0 {name=l48 lab=[15]}
C {devices/bus_tap.sym} 2090 -1470 3 0 {name=l49 lab=[16]}
C {devices/bus_tap.sym} 2140 -1470 3 0 {name=l50 lab=[17]}
C {devices/bus_tap.sym} 2190 -1470 3 0 {name=l51 lab=[18]}
C {devices/bus_tap.sym} 2240 -1470 3 0 {name=l52 lab=[19]}
C {devices/bus_tap.sym} 2290 -1470 3 0 {name=l53 lab=[20]}
C {devices/bus_tap.sym} 2340 -1470 3 0 {name=l54 lab=[21]}
C {devices/bus_tap.sym} 2390 -1470 3 0 {name=l55 lab=[22]}
C {devices/bus_tap.sym} 2440 -1470 3 0 {name=l56 lab=[23]}
C {devices/bus_tap.sym} 2490 -1470 3 0 {name=l57 lab=[24]}
C {devices/bus_tap.sym} 2540 -1470 3 0 {name=l58 lab=[25]}
C {devices/bus_tap.sym} 2590 -1470 3 0 {name=l59 lab=[26]}
C {devices/bus_tap.sym} 2640 -1470 3 0 {name=l60 lab=[27]}
C {devices/bus_tap.sym} 2690 -1470 3 0 {name=l61 lab=[28]}
C {devices/bus_tap.sym} 2740 -1470 3 0 {name=l62 lab=[29]}
C {devices/bus_tap.sym} 2790 -1470 3 0 {name=l63 lab=[30]}
C {devices/bus_tap.sym} 2840 -1470 3 0 {name=l64 lab=[31]}
C {devices/opin.sym} 2880 -1420 0 0 {name=p10 sig_type=std_logic lab=O[31:0]}
C {1 bit 6-T SRAM.sym} 2840 -1600 1 0 {name=x32}
C {devices/bus_tap.sym} 1310 -1420 3 0 {name=l1 lab=[0]}
C {devices/bus_tap.sym} 1360 -1420 3 0 {name=l2 lab=[1]}
C {devices/bus_tap.sym} 1410 -1420 3 0 {name=l3 lab=[2]}
C {devices/bus_tap.sym} 1460 -1420 3 0 {name=l4 lab=[3]}
C {devices/bus_tap.sym} 1510 -1420 3 0 {name=l5 lab=[4]}
C {devices/bus_tap.sym} 1560 -1420 3 0 {name=l6 lab=[5]}
C {devices/bus_tap.sym} 1610 -1420 3 0 {name=l7 lab=[6]}
C {devices/bus_tap.sym} 1660 -1420 3 0 {name=l8 lab=[7]}
C {devices/bus_tap.sym} 1710 -1420 3 0 {name=l9 lab=[8]}
C {devices/bus_tap.sym} 1760 -1420 3 0 {name=l10 lab=[9]}
C {devices/bus_tap.sym} 1810 -1420 3 0 {name=l11 lab=[10]}
C {devices/bus_tap.sym} 1860 -1420 3 0 {name=l12 lab=[11]}
C {devices/bus_tap.sym} 1910 -1420 3 0 {name=l13 lab=[12]}
C {devices/bus_tap.sym} 1960 -1420 3 0 {name=l14 lab=[13]}
C {devices/bus_tap.sym} 2010 -1420 3 0 {name=l15 lab=[14]}
C {devices/bus_tap.sym} 2060 -1420 3 0 {name=l16 lab=[15]}
C {devices/bus_tap.sym} 2110 -1420 3 0 {name=l17 lab=[16]}
C {devices/bus_tap.sym} 2160 -1420 3 0 {name=l18 lab=[17]}
C {devices/bus_tap.sym} 2210 -1420 3 0 {name=l19 lab=[18]}
C {devices/bus_tap.sym} 2260 -1420 3 0 {name=l20 lab=[19]}
C {devices/bus_tap.sym} 2310 -1420 3 0 {name=l21 lab=[20]}
C {devices/bus_tap.sym} 2360 -1420 3 0 {name=l22 lab=[21]}
C {devices/bus_tap.sym} 2410 -1420 3 0 {name=l23 lab=[22]}
C {devices/bus_tap.sym} 2460 -1420 3 0 {name=l24 lab=[23]}
C {devices/bus_tap.sym} 2510 -1420 3 0 {name=l25 lab=[24]}
C {devices/bus_tap.sym} 2560 -1420 3 0 {name=l26 lab=[25]}
C {devices/bus_tap.sym} 2610 -1420 3 0 {name=l27 lab=[26]}
C {devices/bus_tap.sym} 2660 -1420 3 0 {name=l28 lab=[27]}
C {devices/bus_tap.sym} 2710 -1420 3 0 {name=l29 lab=[28]}
C {devices/bus_tap.sym} 2760 -1420 3 0 {name=l30 lab=[29]}
C {devices/bus_tap.sym} 2810 -1420 3 0 {name=l31 lab=[30]}
C {devices/bus_tap.sym} 2860 -1420 3 0 {name=l32 lab=[31]}
C {devices/opin.sym} 2880 -1470 0 0 {name=p1 sig_type=std_logic lab=!O[31:0]}
C {devices/ipin.sym} 1240 -1660 0 0 {name=p2 sig_type=std_logic lab=!O[31:0]}
