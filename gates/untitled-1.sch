v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {1bit comparator.sym} 1320 -2410 0 0 {name=x1}
C {1bit comparator.sym} 1320 -2320 0 0 {name=x2}
C {1bit comparator.sym} 1320 -2240 0 0 {name=x3}
C {1bit comparator.sym} 1320 -2160 0 0 {name=x4}
