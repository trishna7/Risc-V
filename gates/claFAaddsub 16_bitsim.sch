v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
B 2 2378 -2473 3178 -2073 {flags=graph
y1=0
y2=2
ypos1=-0.41094532
ypos2=1.5890548

subdivy=1
unity=1
x1=-3.0826188e-09
x2=9.6917373e-08


xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
divx=10
divy=5
subdivx=1
digital=1


color="11 11 11"
node="a;a3,a2,a1,a0,a3,a2,a1,a0,a3,a2,a1,a0,a3,a2,a1,a0,a3,a2,a1,a0,a3,a2,a1,a0,a3,a2,a1,a0,a3,a2,a1,a0
b;b3,b2,b1,b0,b3,b2,b1,b0,b3,b2,b1,b0,b3,b2,b1,b0,
s;cout,s31,s30,s29,s28,s27,s26,s25,s24,s23,s22,s21,s20,s19,s18,s17,s16,s15,s14,s13,s12,s11,s10,s9,s8,s7,s6,s5,s4,s3,s2,s1,s0"}
B 2 3688 -2503 4488 -2103 {flags=graph
y1=0
y2=2
ypos1=-0.11094529
ypos2=1.8890548

subdivy=1
unity=1
x1=-3.0826188e-09
x2=9.6917373e-08


xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
divx=10
divy=5
subdivx=1
digital=1



color="4 4 4 4 4 4 4 4"
node="s7
s6
s5
s4
s3
s2
s1
s0"}
N 1850 -1470 1850 -1440 {
lab=#net1}
N 1850 -1440 1910 -1440 {
lab=#net1}
N 1850 -1420 1850 -1380 {
lab=#net2}
N 1850 -1420 1910 -1420 {
lab=#net2}
N 1660 -1650 1720 -1650 {
lab=Cin}
N 1660 -1650 1660 -1490 {
lab=Cin}
N 1660 -1490 1660 -1480 {
lab=Cin}
N 1660 -1480 1720 -1480 {
lab=Cin}
N 1630 -1460 1720 -1460 {
lab=#net3}
N 1630 -1670 1630 -1460 {
lab=#net3}
N 1630 -1670 1720 -1670 {
lab=#net3}
N 1570 -1670 1630 -1670 {
lab=#net3}
N 1800 -1470 1850 -1470 {
lab=#net1}
N 1800 -1380 1850 -1380 {
lab=#net2}
N 2040 -1430 2080 -1430 {
lab=Co1}
N 1860 -1660 1920 -1660 {
lab=S0}
N 1325 -1680 1430 -1680 {
lab=A0}
N 1325 -1660 1430 -1660 {
lab=#net4}
N 1385 -1390 1720 -1390 {
lab=A0}
N 1385 -1680 1385 -1390 {
lab=A0}
N 1355 -1370 1720 -1370 {
lab=#net4}
N 1355 -1660 1355 -1370 {
lab=#net4}
N 1330 -1480 1660 -1480 {
lab=Cin}
N 2710 -1470 2710 -1440 {
lab=#net5}
N 2710 -1440 2770 -1440 {
lab=#net5}
N 2710 -1420 2710 -1380 {
lab=#net6}
N 2710 -1420 2770 -1420 {
lab=#net6}
N 2520 -1650 2580 -1650 {
lab=#net7}
N 2520 -1650 2520 -1490 {
lab=#net7}
N 2520 -1490 2520 -1480 {
lab=#net7}
N 2520 -1480 2580 -1480 {
lab=#net7}
N 2490 -1460 2580 -1460 {
lab=#net8}
N 2490 -1670 2490 -1460 {
lab=#net8}
N 2490 -1670 2580 -1670 {
lab=#net8}
N 2430 -1670 2490 -1670 {
lab=#net8}
N 2660 -1470 2710 -1470 {
lab=#net5}
N 2660 -1380 2710 -1380 {
lab=#net6}
N 2900 -1430 2940 -1430 {
lab=Co2}
N 2720 -1660 2780 -1660 {
lab=S1}
N 2185 -1680 2290 -1680 {
lab=A1}
N 2185 -1660 2290 -1660 {
lab=#net9}
N 2245 -1390 2580 -1390 {
lab=A1}
N 2245 -1680 2245 -1390 {
lab=A1}
N 2215 -1370 2580 -1370 {
lab=#net9}
N 2215 -1660 2215 -1370 {
lab=#net9}
N 2190 -1480 2520 -1480 {
lab=#net7}
N 3620 -1480 3620 -1450 {
lab=#net10}
N 3620 -1450 3680 -1450 {
lab=#net10}
N 3620 -1430 3620 -1390 {
lab=#net11}
N 3620 -1430 3680 -1430 {
lab=#net11}
N 3430 -1660 3490 -1660 {
lab=#net12}
N 3430 -1660 3430 -1500 {
lab=#net12}
N 3430 -1500 3430 -1490 {
lab=#net12}
N 3430 -1490 3490 -1490 {
lab=#net12}
N 3400 -1470 3490 -1470 {
lab=#net13}
N 3400 -1680 3400 -1470 {
lab=#net13}
N 3400 -1680 3490 -1680 {
lab=#net13}
N 3340 -1680 3400 -1680 {
lab=#net13}
N 3570 -1480 3620 -1480 {
lab=#net10}
N 3570 -1390 3620 -1390 {
lab=#net11}
N 3810 -1440 3850 -1440 {
lab=Co3}
N 3630 -1670 3690 -1670 {
lab=S2}
N 3095 -1690 3200 -1690 {
lab=A2}
N 3095 -1670 3200 -1670 {
lab=#net14}
N 3155 -1400 3490 -1400 {
lab=A2}
N 3155 -1690 3155 -1400 {
lab=A2}
N 3125 -1380 3490 -1380 {
lab=#net14}
N 3125 -1670 3125 -1380 {
lab=#net14}
N 3100 -1490 3430 -1490 {
lab=#net12}
N 4270 -1640 4330 -1640 {
lab=#net15}
N 4270 -1640 4270 -1480 {
lab=#net15}
N 4270 -1480 4270 -1470 {
lab=#net15}
N 4270 -1470 4330 -1470 {
lab=#net15}
N 4240 -1450 4330 -1450 {
lab=#net16}
N 4650 -1420 4690 -1420 {
lab=Co4}
N 4470 -1650 4530 -1650 {
lab=S3}
N 3935 -1670 4040 -1670 {
lab=A3}
N 3935 -1650 4040 -1650 {
lab=#net17}
N 3995 -1380 4330 -1380 {
lab=A3}
N 3995 -1670 3995 -1380 {
lab=A3}
N 3965 -1360 4330 -1360 {
lab=#net17}
N 3965 -1650 3965 -1360 {
lab=#net17}
N 3940 -1470 4270 -1470 {
lab=#net15}
N 1800 -1380 1800 -1020 {
lab=#net2}
N 1800 -1020 3090 -1020 {
lab=#net2}
N 3090 -1020 3090 -880 {
lab=#net2}
N 1630 -1460 1630 -990 {
lab=#net3}
N 1630 -990 2930 -990 {
lab=#net3}
N 2930 -990 2930 -880 {
lab=#net3}
N 2490 -1460 2490 -960 {
lab=#net8}
N 2490 -960 2940 -960 {
lab=#net8}
N 2940 -960 2950 -960 {
lab=#net8}
N 2950 -960 2950 -880 {
lab=#net8}
N 2690 -1380 2690 -1050 {
lab=#net6}
N 2690 -1050 3060 -1050 {
lab=#net6}
N 3060 -1050 3070 -1050 {
lab=#net6}
N 3070 -1050 3070 -880 {
lab=#net6}
N 2970 -1130 2970 -880 {
lab=#net13}
N 2970 -1130 3400 -1130 {
lab=#net13}
N 3400 -1470 3400 -1130 {
lab=#net13}
N 3570 -1390 3570 -960 {
lab=#net11}
N 3050 -960 3570 -960 {
lab=#net11}
N 3050 -960 3050 -880 {
lab=#net11}
N 4240 -1450 4240 -920 {
lab=#net16}
N 2990 -920 4240 -920 {
lab=#net16}
N 2990 -920 2990 -880 {
lab=#net16}
N 1300 -810 2870 -810 {
lab=Cin}
N 1300 -1480 1300 -810 {
lab=Cin}
N 1300 -1480 1330 -1480 {
lab=Cin}
N 2190 -1480 2190 -690 {
lab=#net7}
N 2190 -690 3180 -690 {
lab=#net7}
N 3180 -830 3180 -690 {
lab=#net7}
N 3140 -830 3180 -830 {
lab=#net7}
N 3100 -1490 3100 -1170 {
lab=#net12}
N 3100 -1170 3260 -1170 {
lab=#net12}
N 3260 -1170 3260 -810 {
lab=#net12}
N 3140 -810 3260 -810 {
lab=#net12}
N 3140 -790 3950 -790 {
lab=#net15}
N 3950 -1470 3950 -790 {
lab=#net15}
N 3140 -770 3200 -770 {
lab=#net18}
N 4460 -1430 4520 -1430 {
lab=#net19}
N 4460 -1460 4460 -1430 {
lab=#net19}
N 4410 -1460 4460 -1460 {
lab=#net19}
N 4180 -1660 4330 -1660 {
lab=#net16}
N 4240 -1660 4240 -1450 {
lab=#net16}
N 4460 -1410 4520 -1410 {
lab=#net20}
N 4460 -1410 4460 -1370 {
lab=#net20}
N 4410 -1370 4460 -1370 {
lab=#net20}
N 4460 -1370 4460 -900 {
lab=#net20}
N 3030 -900 4460 -900 {
lab=#net20}
N 3030 -900 3030 -880 {
lab=#net20}
N 1100 -1760 1120 -1760 {
lab=B0}
N 1260 -1770 1350 -1770 {
lab=#net4}
N 1350 -1770 1350 -1660 {
lab=#net4}
N 2030 -1760 2070 -1760 {
lab=B1}
N 2210 -1770 2210 -1660 {
lab=#net9}
N 3090 -1770 3110 -1770 {
lab=#net14}
N 3110 -1770 3110 -1670 {
lab=#net14}
N 2920 -1760 2950 -1760 {
lab=B2}
N 3930 -1760 3960 -1760 {
lab=#net17}
N 3960 -1760 3960 -1650 {
lab=#net17}
N 3760 -1750 3790 -1750 {
lab=B3}
N 3710 -1770 3790 -1770 {
lab=Cin}
N 3710 -1840 3710 -1770 {
lab=Cin}
N 2920 -1840 3710 -1840 {
lab=Cin}
N 2920 -1840 2920 -1780 {
lab=Cin}
N 2920 -1780 2950 -1780 {
lab=Cin}
N 1990 -1840 2920 -1840 {
lab=Cin}
N 1990 -1840 1990 -1790 {
lab=Cin}
N 1990 -1790 1990 -1780 {
lab=Cin}
N 1990 -1780 2070 -1780 {
lab=Cin}
N 1090 -1840 1990 -1840 {
lab=Cin}
N 1090 -1840 1090 -1780 {
lab=Cin}
N 1090 -1780 1120 -1780 {
lab=Cin}
N 1000 -1840 1090 -1840 {
lab=Cin}
N 1000 -1840 1000 -1560 {
lab=Cin}
N 1000 -1560 1300 -1560 {
lab=Cin}
N 1300 -1560 1300 -1480 {
lab=Cin}
N 5580 -1480 5580 -1450 {
lab=#net21}
N 5580 -1450 5640 -1450 {
lab=#net21}
N 5580 -1430 5580 -1390 {
lab=#net22}
N 5580 -1430 5640 -1430 {
lab=#net22}
N 5390 -1660 5450 -1660 {
lab=#net18}
N 5390 -1660 5390 -1500 {
lab=#net18}
N 5390 -1500 5390 -1490 {
lab=#net18}
N 5390 -1490 5450 -1490 {
lab=#net18}
N 5360 -1470 5450 -1470 {
lab=#net23}
N 5360 -1680 5360 -1470 {
lab=#net23}
N 5360 -1680 5450 -1680 {
lab=#net23}
N 5300 -1680 5360 -1680 {
lab=#net23}
N 5530 -1480 5580 -1480 {
lab=#net21}
N 5530 -1390 5580 -1390 {
lab=#net22}
N 5770 -1440 5810 -1440 {
lab=Co5}
N 5590 -1670 5650 -1670 {
lab=S4}
N 5055 -1690 5160 -1690 {
lab=A0}
N 5055 -1670 5160 -1670 {
lab=#net24}
N 5115 -1400 5450 -1400 {
lab=A0}
N 5115 -1690 5115 -1400 {
lab=A0}
N 5085 -1380 5450 -1380 {
lab=#net24}
N 5085 -1670 5085 -1380 {
lab=#net24}
N 5060 -1490 5390 -1490 {
lab=#net18}
N 6440 -1480 6440 -1450 {
lab=#net25}
N 6440 -1450 6500 -1450 {
lab=#net25}
N 6440 -1430 6440 -1390 {
lab=#net26}
N 6440 -1430 6500 -1430 {
lab=#net26}
N 6250 -1660 6310 -1660 {
lab=#net27}
N 6250 -1660 6250 -1500 {
lab=#net27}
N 6250 -1500 6250 -1490 {
lab=#net27}
N 6250 -1490 6310 -1490 {
lab=#net27}
N 6220 -1470 6310 -1470 {
lab=#net28}
N 6220 -1680 6220 -1470 {
lab=#net28}
N 6220 -1680 6310 -1680 {
lab=#net28}
N 6160 -1680 6220 -1680 {
lab=#net28}
N 6390 -1480 6440 -1480 {
lab=#net25}
N 6390 -1390 6440 -1390 {
lab=#net26}
N 6630 -1440 6670 -1440 {
lab=Co6}
N 6450 -1670 6510 -1670 {
lab=S5}
N 5915 -1690 6020 -1690 {
lab=A1}
N 5915 -1670 6020 -1670 {
lab=#net29}
N 5975 -1400 6310 -1400 {
lab=A1}
N 5975 -1690 5975 -1400 {
lab=A1}
N 5945 -1380 6310 -1380 {
lab=#net29}
N 5945 -1670 5945 -1380 {
lab=#net29}
N 5920 -1490 6250 -1490 {
lab=#net27}
N 7350 -1490 7350 -1460 {
lab=#net30}
N 7350 -1460 7410 -1460 {
lab=#net30}
N 7350 -1440 7350 -1400 {
lab=#net31}
N 7350 -1440 7410 -1440 {
lab=#net31}
N 7160 -1670 7220 -1670 {
lab=#net32}
N 7160 -1670 7160 -1510 {
lab=#net32}
N 7160 -1510 7160 -1500 {
lab=#net32}
N 7160 -1500 7220 -1500 {
lab=#net32}
N 7130 -1480 7220 -1480 {
lab=#net33}
N 7130 -1690 7130 -1480 {
lab=#net33}
N 7130 -1690 7220 -1690 {
lab=#net33}
N 7070 -1690 7130 -1690 {
lab=#net33}
N 7300 -1490 7350 -1490 {
lab=#net30}
N 7300 -1400 7350 -1400 {
lab=#net31}
N 7540 -1450 7580 -1450 {
lab=Co7}
N 7360 -1680 7420 -1680 {
lab=S6}
N 6825 -1700 6930 -1700 {
lab=A2}
N 6825 -1680 6930 -1680 {
lab=#net34}
N 6885 -1410 7220 -1410 {
lab=A2}
N 6885 -1700 6885 -1410 {
lab=A2}
N 6855 -1390 7220 -1390 {
lab=#net34}
N 6855 -1680 6855 -1390 {
lab=#net34}
N 6830 -1500 7160 -1500 {
lab=#net32}
N 8000 -1650 8060 -1650 {
lab=C3}
N 8000 -1650 8000 -1490 {
lab=C3}
N 8000 -1490 8000 -1480 {
lab=C3}
N 8000 -1480 8060 -1480 {
lab=C3}
N 7970 -1460 8060 -1460 {
lab=#net35}
N 8380 -1430 8420 -1430 {
lab=Co8}
N 8200 -1660 8260 -1660 {
lab=S7}
N 7665 -1680 7770 -1680 {
lab=A3}
N 7665 -1660 7770 -1660 {
lab=#net36}
N 7725 -1390 8060 -1390 {
lab=A3}
N 7725 -1680 7725 -1390 {
lab=A3}
N 7695 -1370 8060 -1370 {
lab=#net36}
N 7695 -1660 7695 -1370 {
lab=#net36}
N 7670 -1480 8000 -1480 {
lab=C3}
N 5530 -1390 5530 -1030 {
lab=#net22}
N 5530 -1030 6820 -1030 {
lab=#net22}
N 6820 -1030 6820 -890 {
lab=#net22}
N 5360 -1470 5360 -1000 {
lab=#net23}
N 5360 -1000 6660 -1000 {
lab=#net23}
N 6660 -1000 6660 -890 {
lab=#net23}
N 6220 -1470 6220 -970 {
lab=#net28}
N 6220 -970 6670 -970 {
lab=#net28}
N 6670 -970 6680 -970 {
lab=#net28}
N 6680 -970 6680 -890 {
lab=#net28}
N 6420 -1390 6420 -1060 {
lab=#net26}
N 6420 -1060 6790 -1060 {
lab=#net26}
N 6790 -1060 6800 -1060 {
lab=#net26}
N 6800 -1060 6800 -890 {
lab=#net26}
N 6700 -1140 6700 -890 {
lab=#net33}
N 6700 -1140 7130 -1140 {
lab=#net33}
N 7130 -1480 7130 -1140 {
lab=#net33}
N 7300 -1400 7300 -970 {
lab=#net31}
N 6780 -970 7300 -970 {
lab=#net31}
N 6780 -970 6780 -890 {
lab=#net31}
N 7970 -1460 7970 -930 {
lab=#net35}
N 6720 -930 7970 -930 {
lab=#net35}
N 6720 -930 6720 -890 {
lab=#net35}
N 5030 -1490 5060 -1490 {
lab=#net18}
N 5920 -1490 5920 -700 {
lab=#net27}
N 5920 -700 6910 -700 {
lab=#net27}
N 6910 -840 6910 -700 {
lab=#net27}
N 6870 -840 6910 -840 {
lab=#net27}
N 6830 -1500 6830 -1180 {
lab=#net32}
N 6830 -1180 6990 -1180 {
lab=#net32}
N 6990 -1180 6990 -820 {
lab=#net32}
N 6870 -820 6990 -820 {
lab=#net32}
N 6870 -800 7680 -800 {
lab=C3}
N 7680 -1480 7680 -800 {
lab=C3}
N 6870 -780 6930 -780 {
lab=#net37}
N 8190 -1440 8250 -1440 {
lab=#net38}
N 8190 -1470 8190 -1440 {
lab=#net38}
N 8140 -1470 8190 -1470 {
lab=#net38}
N 7910 -1670 8060 -1670 {
lab=#net35}
N 7970 -1670 7970 -1460 {
lab=#net35}
N 8190 -1420 8250 -1420 {
lab=#net39}
N 8190 -1420 8190 -1380 {
lab=#net39}
N 8140 -1380 8190 -1380 {
lab=#net39}
N 8190 -1380 8190 -910 {
lab=#net39}
N 6760 -910 8190 -910 {
lab=#net39}
N 6760 -910 6760 -890 {
lab=#net39}
N 4830 -1770 4850 -1770 {
lab=B0}
N 4990 -1780 5080 -1780 {
lab=#net24}
N 5080 -1780 5080 -1670 {
lab=#net24}
N 5760 -1770 5800 -1770 {
lab=B1}
N 5940 -1780 5940 -1670 {
lab=#net29}
N 6820 -1780 6840 -1780 {
lab=#net34}
N 6840 -1780 6840 -1680 {
lab=#net34}
N 6650 -1770 6680 -1770 {
lab=B2}
N 7660 -1770 7690 -1770 {
lab=#net36}
N 7690 -1770 7690 -1660 {
lab=#net36}
N 7490 -1760 7520 -1760 {
lab=B3}
N 7440 -1780 7520 -1780 {
lab=Cin}
N 7440 -1850 7440 -1780 {
lab=Cin}
N 6650 -1850 7440 -1850 {
lab=Cin}
N 6650 -1850 6650 -1790 {
lab=Cin}
N 6650 -1790 6680 -1790 {
lab=Cin}
N 5720 -1850 6650 -1850 {
lab=Cin}
N 5720 -1850 5720 -1800 {
lab=Cin}
N 5720 -1800 5720 -1790 {
lab=Cin}
N 5720 -1790 5800 -1790 {
lab=Cin}
N 4820 -1850 5720 -1850 {
lab=Cin}
N 4820 -1850 4820 -1790 {
lab=Cin}
N 4820 -1790 4850 -1790 {
lab=Cin}
N 4730 -1850 4820 -1850 {
lab=Cin}
N 3200 -770 4910 -770 {
lab=#net18}
N 4910 -1490 4910 -770 {
lab=#net18}
N 4910 -1490 5030 -1490 {
lab=#net18}
N 3710 -1850 4740 -1850 {
lab=Cin}
N 3710 -1850 3710 -1830 {
lab=Cin}
N 4910 -820 6600 -820 {
lab=#net18}
N 9420 -1490 9420 -1460 {
lab=#net40}
N 9420 -1460 9480 -1460 {
lab=#net40}
N 9420 -1440 9420 -1400 {
lab=#net41}
N 9420 -1440 9480 -1440 {
lab=#net41}
N 9230 -1670 9290 -1670 {
lab=#net37}
N 9230 -1670 9230 -1510 {
lab=#net37}
N 9230 -1510 9230 -1500 {
lab=#net37}
N 9230 -1500 9290 -1500 {
lab=#net37}
N 9200 -1480 9290 -1480 {
lab=#net42}
N 9200 -1690 9200 -1480 {
lab=#net42}
N 9200 -1690 9290 -1690 {
lab=#net42}
N 9140 -1690 9200 -1690 {
lab=#net42}
N 9370 -1490 9420 -1490 {
lab=#net40}
N 9370 -1400 9420 -1400 {
lab=#net41}
N 9610 -1450 9650 -1450 {
lab=Co9}
N 9430 -1680 9490 -1680 {
lab=S8}
N 8895 -1700 9000 -1700 {
lab=A0}
N 8895 -1680 9000 -1680 {
lab=#net43}
N 8955 -1410 9290 -1410 {
lab=A0}
N 8955 -1700 8955 -1410 {
lab=A0}
N 8925 -1390 9290 -1390 {
lab=#net43}
N 8925 -1680 8925 -1390 {
lab=#net43}
N 8900 -1500 9230 -1500 {
lab=#net37}
N 10280 -1490 10280 -1460 {
lab=#net44}
N 10280 -1460 10340 -1460 {
lab=#net44}
N 10280 -1440 10280 -1400 {
lab=#net45}
N 10280 -1440 10340 -1440 {
lab=#net45}
N 10090 -1670 10150 -1670 {
lab=#net46}
N 10090 -1670 10090 -1510 {
lab=#net46}
N 10090 -1510 10090 -1500 {
lab=#net46}
N 10090 -1500 10150 -1500 {
lab=#net46}
N 10060 -1480 10150 -1480 {
lab=#net47}
N 10060 -1690 10060 -1480 {
lab=#net47}
N 10060 -1690 10150 -1690 {
lab=#net47}
N 10000 -1690 10060 -1690 {
lab=#net47}
N 10230 -1490 10280 -1490 {
lab=#net44}
N 10230 -1400 10280 -1400 {
lab=#net45}
N 10470 -1450 10510 -1450 {
lab=Co10}
N 10290 -1680 10350 -1680 {
lab=S9}
N 9755 -1700 9860 -1700 {
lab=A1}
N 9755 -1680 9860 -1680 {
lab=#net48}
N 9815 -1410 10150 -1410 {
lab=A1}
N 9815 -1700 9815 -1410 {
lab=A1}
N 9785 -1390 10150 -1390 {
lab=#net48}
N 9785 -1680 9785 -1390 {
lab=#net48}
N 9760 -1500 10090 -1500 {
lab=#net46}
N 11190 -1500 11190 -1470 {
lab=#net49}
N 11190 -1470 11250 -1470 {
lab=#net49}
N 11190 -1450 11190 -1410 {
lab=#net50}
N 11190 -1450 11250 -1450 {
lab=#net50}
N 11000 -1680 11060 -1680 {
lab=#net51}
N 11000 -1680 11000 -1520 {
lab=#net51}
N 11000 -1520 11000 -1510 {
lab=#net51}
N 11000 -1510 11060 -1510 {
lab=#net51}
N 10970 -1490 11060 -1490 {
lab=#net52}
N 10970 -1700 10970 -1490 {
lab=#net52}
N 10970 -1700 11060 -1700 {
lab=#net52}
N 10910 -1700 10970 -1700 {
lab=#net52}
N 11140 -1500 11190 -1500 {
lab=#net49}
N 11140 -1410 11190 -1410 {
lab=#net50}
N 11380 -1460 11420 -1460 {
lab=C3}
N 11200 -1690 11260 -1690 {
lab=S10}
N 10665 -1710 10770 -1710 {
lab=A2}
N 10665 -1690 10770 -1690 {
lab=#net53}
N 10725 -1420 11060 -1420 {
lab=A2}
N 10725 -1710 10725 -1420 {
lab=A2}
N 10695 -1400 11060 -1400 {
lab=#net53}
N 10695 -1690 10695 -1400 {
lab=#net53}
N 10670 -1510 11000 -1510 {
lab=#net51}
N 11840 -1660 11900 -1660 {
lab=#net54}
N 11840 -1660 11840 -1500 {
lab=#net54}
N 11840 -1500 11840 -1490 {
lab=#net54}
N 11840 -1490 11900 -1490 {
lab=#net54}
N 11810 -1470 11900 -1470 {
lab=#net55}
N 12220 -1440 12260 -1440 {
lab=C4}
N 12040 -1670 12100 -1670 {
lab=S11}
N 11505 -1690 11610 -1690 {
lab=A3}
N 11505 -1670 11610 -1670 {
lab=#net56}
N 11565 -1400 11900 -1400 {
lab=A3}
N 11565 -1690 11565 -1400 {
lab=A3}
N 11535 -1380 11900 -1380 {
lab=#net56}
N 11535 -1670 11535 -1380 {
lab=#net56}
N 11510 -1490 11840 -1490 {
lab=#net54}
N 9370 -1400 9370 -1040 {
lab=#net41}
N 9370 -1040 10660 -1040 {
lab=#net41}
N 10660 -1040 10660 -900 {
lab=#net41}
N 9200 -1480 9200 -1010 {
lab=#net42}
N 9200 -1010 10500 -1010 {
lab=#net42}
N 10500 -1010 10500 -900 {
lab=#net42}
N 10060 -1480 10060 -980 {
lab=#net47}
N 10060 -980 10510 -980 {
lab=#net47}
N 10510 -980 10520 -980 {
lab=#net47}
N 10520 -980 10520 -900 {
lab=#net47}
N 10260 -1400 10260 -1070 {
lab=#net45}
N 10260 -1070 10630 -1070 {
lab=#net45}
N 10630 -1070 10640 -1070 {
lab=#net45}
N 10640 -1070 10640 -900 {
lab=#net45}
N 10540 -1150 10540 -900 {
lab=#net52}
N 10540 -1150 10970 -1150 {
lab=#net52}
N 10970 -1490 10970 -1150 {
lab=#net52}
N 11140 -1410 11140 -980 {
lab=#net50}
N 10620 -980 11140 -980 {
lab=#net50}
N 10620 -980 10620 -900 {
lab=#net50}
N 11810 -1470 11810 -940 {
lab=#net55}
N 10560 -940 11810 -940 {
lab=#net55}
N 10560 -940 10560 -900 {
lab=#net55}
N 8870 -830 10440 -830 {
lab=#net37}
N 8870 -1500 8900 -1500 {
lab=#net37}
N 9760 -1500 9760 -710 {
lab=#net46}
N 9760 -710 10750 -710 {
lab=#net46}
N 10750 -850 10750 -710 {
lab=#net46}
N 10710 -850 10750 -850 {
lab=#net46}
N 10670 -1510 10670 -1190 {
lab=#net51}
N 10670 -1190 10830 -1190 {
lab=#net51}
N 10830 -1190 10830 -830 {
lab=#net51}
N 10710 -830 10830 -830 {
lab=#net51}
N 10710 -810 11520 -810 {
lab=#net54}
N 11520 -1490 11520 -810 {
lab=#net54}
N 10710 -790 10770 -790 {
lab=#net57}
N 12030 -1450 12090 -1450 {
lab=#net58}
N 12030 -1480 12030 -1450 {
lab=#net58}
N 11980 -1480 12030 -1480 {
lab=#net58}
N 11750 -1680 11900 -1680 {
lab=#net55}
N 11810 -1680 11810 -1470 {
lab=#net55}
N 12030 -1430 12090 -1430 {
lab=#net59}
N 12030 -1430 12030 -1390 {
lab=#net59}
N 11980 -1390 12030 -1390 {
lab=#net59}
N 12030 -1390 12030 -920 {
lab=#net59}
N 10600 -920 12030 -920 {
lab=#net59}
N 10600 -920 10600 -900 {
lab=#net59}
N 8670 -1780 8690 -1780 {
lab=B0}
N 8830 -1790 8920 -1790 {
lab=#net43}
N 8920 -1790 8920 -1680 {
lab=#net43}
N 9600 -1780 9640 -1780 {
lab=B1}
N 9780 -1790 9780 -1680 {
lab=#net48}
N 10660 -1790 10680 -1790 {
lab=#net53}
N 10680 -1790 10680 -1690 {
lab=#net53}
N 10490 -1780 10520 -1780 {
lab=B2}
N 11500 -1780 11530 -1780 {
lab=#net56}
N 11530 -1780 11530 -1670 {
lab=#net56}
N 11330 -1770 11360 -1770 {
lab=B3}
N 11280 -1790 11360 -1790 {
lab=Cin}
N 11280 -1860 11280 -1790 {
lab=Cin}
N 10490 -1860 11280 -1860 {
lab=Cin}
N 10490 -1860 10490 -1800 {
lab=Cin}
N 10490 -1800 10520 -1800 {
lab=Cin}
N 9560 -1860 10490 -1860 {
lab=Cin}
N 9560 -1860 9560 -1810 {
lab=Cin}
N 9560 -1810 9560 -1800 {
lab=Cin}
N 9560 -1800 9640 -1800 {
lab=Cin}
N 8660 -1860 9560 -1860 {
lab=Cin}
N 8660 -1860 8660 -1800 {
lab=Cin}
N 8660 -1800 8690 -1800 {
lab=Cin}
N 8570 -1860 8660 -1860 {
lab=Cin}
N 13150 -1500 13150 -1470 {
lab=#net60}
N 13150 -1470 13210 -1470 {
lab=#net60}
N 13150 -1450 13150 -1410 {
lab=#net61}
N 13150 -1450 13210 -1450 {
lab=#net61}
N 12960 -1680 13020 -1680 {
lab=#net57}
N 12960 -1680 12960 -1520 {
lab=#net57}
N 12960 -1520 12960 -1510 {
lab=#net57}
N 12960 -1510 13020 -1510 {
lab=#net57}
N 12930 -1490 13020 -1490 {
lab=#net62}
N 12930 -1700 12930 -1490 {
lab=#net62}
N 12930 -1700 13020 -1700 {
lab=#net62}
N 12870 -1700 12930 -1700 {
lab=#net62}
N 13100 -1500 13150 -1500 {
lab=#net60}
N 13100 -1410 13150 -1410 {
lab=#net61}
N 13340 -1460 13380 -1460 {
lab=C5}
N 13160 -1690 13220 -1690 {
lab=S12}
N 12625 -1710 12730 -1710 {
lab=A0}
N 12625 -1690 12730 -1690 {
lab=#net63}
N 12685 -1420 13020 -1420 {
lab=A0}
N 12685 -1710 12685 -1420 {
lab=A0}
N 12655 -1400 13020 -1400 {
lab=#net63}
N 12655 -1690 12655 -1400 {
lab=#net63}
N 12630 -1510 12960 -1510 {
lab=#net57}
N 14010 -1500 14010 -1470 {
lab=#net64}
N 14010 -1470 14070 -1470 {
lab=#net64}
N 14010 -1450 14010 -1410 {
lab=#net65}
N 14010 -1450 14070 -1450 {
lab=#net65}
N 13820 -1680 13880 -1680 {
lab=C1}
N 13820 -1680 13820 -1520 {
lab=C1}
N 13820 -1520 13820 -1510 {
lab=C1}
N 13820 -1510 13880 -1510 {
lab=C1}
N 13790 -1490 13880 -1490 {
lab=#net66}
N 13790 -1700 13790 -1490 {
lab=#net66}
N 13790 -1700 13880 -1700 {
lab=#net66}
N 13730 -1700 13790 -1700 {
lab=#net66}
N 13960 -1500 14010 -1500 {
lab=#net64}
N 13960 -1410 14010 -1410 {
lab=#net65}
N 14200 -1460 14240 -1460 {
lab=C6}
N 14020 -1690 14080 -1690 {
lab=S13}
N 13485 -1710 13590 -1710 {
lab=A1}
N 13485 -1690 13590 -1690 {
lab=#net67}
N 13545 -1420 13880 -1420 {
lab=A1}
N 13545 -1710 13545 -1420 {
lab=A1}
N 13515 -1400 13880 -1400 {
lab=#net67}
N 13515 -1690 13515 -1400 {
lab=#net67}
N 13490 -1510 13820 -1510 {
lab=C1}
N 14920 -1510 14920 -1480 {
lab=#net68}
N 14920 -1480 14980 -1480 {
lab=#net68}
N 14920 -1460 14920 -1420 {
lab=#net69}
N 14920 -1460 14980 -1460 {
lab=#net69}
N 14730 -1690 14790 -1690 {
lab=#net70}
N 14730 -1690 14730 -1530 {
lab=#net70}
N 14730 -1530 14730 -1520 {
lab=#net70}
N 14730 -1520 14790 -1520 {
lab=#net70}
N 14700 -1500 14790 -1500 {
lab=#net71}
N 14700 -1710 14700 -1500 {
lab=#net71}
N 14700 -1710 14790 -1710 {
lab=#net71}
N 14640 -1710 14700 -1710 {
lab=#net71}
N 14870 -1510 14920 -1510 {
lab=#net68}
N 14870 -1420 14920 -1420 {
lab=#net69}
N 15110 -1470 15150 -1470 {
lab=C7}
N 14930 -1700 14990 -1700 {
lab=S14}
N 14395 -1720 14500 -1720 {
lab=A2}
N 14395 -1700 14500 -1700 {
lab=#net72}
N 14455 -1430 14790 -1430 {
lab=A2}
N 14455 -1720 14455 -1430 {
lab=A2}
N 14425 -1410 14790 -1410 {
lab=#net72}
N 14425 -1700 14425 -1410 {
lab=#net72}
N 14400 -1520 14730 -1520 {
lab=#net70}
N 15570 -1670 15630 -1670 {
lab=#net73}
N 15570 -1670 15570 -1510 {
lab=#net73}
N 15570 -1510 15570 -1500 {
lab=#net73}
N 15570 -1500 15630 -1500 {
lab=#net73}
N 15540 -1480 15630 -1480 {
lab=#net74}
N 15770 -1680 15830 -1680 {
lab=S15}
N 15235 -1700 15340 -1700 {
lab=A3}
N 15235 -1680 15340 -1680 {
lab=#net75}
N 15295 -1410 15630 -1410 {
lab=A3}
N 15295 -1700 15295 -1410 {
lab=A3}
N 15265 -1390 15630 -1390 {
lab=#net75}
N 15265 -1680 15265 -1390 {
lab=#net75}
N 15240 -1500 15570 -1500 {
lab=#net73}
N 13100 -1410 13100 -1050 {
lab=#net61}
N 13100 -1050 14390 -1050 {
lab=#net61}
N 14390 -1050 14390 -910 {
lab=#net61}
N 12930 -1490 12930 -1020 {
lab=#net62}
N 12930 -1020 14230 -1020 {
lab=#net62}
N 14230 -1020 14230 -910 {
lab=#net62}
N 13790 -1490 13790 -990 {
lab=#net66}
N 13790 -990 14240 -990 {
lab=#net66}
N 14240 -990 14250 -990 {
lab=#net66}
N 14250 -990 14250 -910 {
lab=#net66}
N 13990 -1410 13990 -1080 {
lab=#net65}
N 13990 -1080 14360 -1080 {
lab=#net65}
N 14360 -1080 14370 -1080 {
lab=#net65}
N 14370 -1080 14370 -910 {
lab=#net65}
N 14270 -1160 14270 -910 {
lab=#net71}
N 14270 -1160 14700 -1160 {
lab=#net71}
N 14700 -1500 14700 -1160 {
lab=#net71}
N 14870 -1420 14870 -990 {
lab=#net69}
N 14350 -990 14870 -990 {
lab=#net69}
N 14350 -990 14350 -910 {
lab=#net69}
N 15540 -1480 15540 -950 {
lab=#net74}
N 14290 -950 15540 -950 {
lab=#net74}
N 14290 -950 14290 -910 {
lab=#net74}
N 12600 -1510 12630 -1510 {
lab=#net57}
N 13490 -1510 13490 -720 {
lab=C1}
N 13490 -720 14480 -720 {
lab=C1}
N 14480 -860 14480 -720 {
lab=C1}
N 14440 -860 14480 -860 {
lab=C1}
N 14400 -1520 14400 -1200 {
lab=#net70}
N 14400 -1200 14560 -1200 {
lab=#net70}
N 14560 -1200 14560 -840 {
lab=#net70}
N 14440 -840 14560 -840 {
lab=#net70}
N 14440 -820 15250 -820 {
lab=#net73}
N 15250 -1500 15250 -820 {
lab=#net73}
N 14440 -800 14500 -800 {
lab=#net76}
N 15760 -1460 15820 -1460 {
lab=#net77}
N 15760 -1490 15760 -1460 {
lab=#net77}
N 15710 -1490 15760 -1490 {
lab=#net77}
N 15480 -1690 15630 -1690 {
lab=#net74}
N 15540 -1690 15540 -1480 {
lab=#net74}
N 15760 -1440 15820 -1440 {
lab=#net78}
N 15760 -1440 15760 -1400 {
lab=#net78}
N 15710 -1400 15760 -1400 {
lab=#net78}
N 15760 -1400 15760 -930 {
lab=#net78}
N 14330 -930 15760 -930 {
lab=#net78}
N 14330 -930 14330 -910 {
lab=#net78}
N 12400 -1790 12420 -1790 {
lab=B0}
N 12560 -1800 12650 -1800 {
lab=#net63}
N 12650 -1800 12650 -1690 {
lab=#net63}
N 13330 -1790 13370 -1790 {
lab=B1}
N 13510 -1800 13510 -1690 {
lab=#net67}
N 14390 -1800 14410 -1800 {
lab=#net72}
N 14410 -1800 14410 -1700 {
lab=#net72}
N 14220 -1790 14250 -1790 {
lab=B2}
N 15230 -1790 15260 -1790 {
lab=#net75}
N 15260 -1790 15260 -1680 {
lab=#net75}
N 15060 -1780 15090 -1780 {
lab=B3}
N 15010 -1800 15090 -1800 {
lab=Cin}
N 15010 -1870 15010 -1800 {
lab=Cin}
N 14220 -1870 15010 -1870 {
lab=Cin}
N 14220 -1870 14220 -1810 {
lab=Cin}
N 14220 -1810 14250 -1810 {
lab=Cin}
N 13290 -1870 14220 -1870 {
lab=Cin}
N 13290 -1870 13290 -1820 {
lab=Cin}
N 13290 -1820 13290 -1810 {
lab=Cin}
N 13290 -1810 13370 -1810 {
lab=Cin}
N 12390 -1870 13290 -1870 {
lab=Cin}
N 12390 -1870 12390 -1810 {
lab=Cin}
N 12390 -1810 12420 -1810 {
lab=Cin}
N 12300 -1870 12390 -1870 {
lab=Cin}
N 10770 -790 12480 -790 {
lab=#net57}
N 12480 -1510 12480 -790 {
lab=#net57}
N 12480 -1510 12600 -1510 {
lab=#net57}
N 11280 -1870 12310 -1870 {
lab=Cin}
N 11280 -1870 11280 -1850 {
lab=Cin}
N 12480 -840 14170 -840 {
lab=#net57}
N 7430 -1860 8570 -1860 {
lab=Cin}
N 7430 -1860 7430 -1850 {
lab=Cin}
N 6930 -780 8870 -780 {
lab=#net37}
N 8870 -830 8870 -780 {
lab=#net37}
N 8870 -1500 8870 -830 {
lab=#net37}
N 14880 240 14880 270 {
lab=#net79}
N 14820 240 14880 240 {
lab=#net79}
N 14880 180 14880 220 {
lab=#net80}
N 14820 220 14880 220 {
lab=#net80}
N 15010 450 15070 450 {
lab=#net76}
N 15070 290 15070 450 {
lab=#net76}
N 15070 280 15070 290 {
lab=#net76}
N 15010 280 15070 280 {
lab=#net76}
N 15010 260 15100 260 {
lab=#net81}
N 15100 260 15100 470 {
lab=#net81}
N 15010 470 15100 470 {
lab=#net81}
N 15100 470 15160 470 {
lab=#net81}
N 14880 270 14930 270 {
lab=#net79}
N 14880 180 14930 180 {
lab=#net80}
N 14650 230 14690 230 {
lab=#net82}
N 14810 460 14870 460 {
lab=S16}
N 15300 480 15405 480 {
lab=A0}
N 15300 460 15405 460 {
lab=#net83}
N 15010 190 15345 190 {
lab=A0}
N 15345 190 15345 480 {
lab=A0}
N 15010 170 15375 170 {
lab=#net83}
N 15375 170 15375 460 {
lab=#net83}
N 15070 280 15400 280 {
lab=#net76}
N 14020 240 14020 270 {
lab=#net84}
N 13960 240 14020 240 {
lab=#net84}
N 14020 180 14020 220 {
lab=#net85}
N 13960 220 14020 220 {
lab=#net85}
N 14150 450 14210 450 {
lab=#net86}
N 14210 290 14210 450 {
lab=#net86}
N 14210 280 14210 290 {
lab=#net86}
N 14150 280 14210 280 {
lab=#net86}
N 14150 260 14240 260 {
lab=#net87}
N 14240 260 14240 470 {
lab=#net87}
N 14150 470 14240 470 {
lab=#net87}
N 14240 470 14300 470 {
lab=#net87}
N 14020 270 14070 270 {
lab=#net84}
N 14020 180 14070 180 {
lab=#net85}
N 13790 230 13830 230 {
lab=#net88}
N 13950 460 14010 460 {
lab=S17}
N 14440 480 14545 480 {
lab=A1}
N 14440 460 14545 460 {
lab=#net89}
N 14150 190 14485 190 {
lab=A1}
N 14485 190 14485 480 {
lab=A1}
N 14150 170 14515 170 {
lab=#net89}
N 14515 170 14515 460 {
lab=#net89}
N 14210 280 14540 280 {
lab=#net86}
N 13110 250 13110 280 {
lab=#net90}
N 13050 250 13110 250 {
lab=#net90}
N 13110 190 13110 230 {
lab=#net91}
N 13050 230 13110 230 {
lab=#net91}
N 13240 460 13300 460 {
lab=#net92}
N 13300 300 13300 460 {
lab=#net92}
N 13300 290 13300 300 {
lab=#net92}
N 13240 290 13300 290 {
lab=#net92}
N 13240 270 13330 270 {
lab=#net93}
N 13330 270 13330 480 {
lab=#net93}
N 13240 480 13330 480 {
lab=#net93}
N 13330 480 13390 480 {
lab=#net93}
N 13110 280 13160 280 {
lab=#net90}
N 13110 190 13160 190 {
lab=#net91}
N 12880 240 12920 240 {
lab=#net94}
N 13040 470 13100 470 {
lab=S18}
N 13530 490 13635 490 {
lab=A2}
N 13530 470 13635 470 {
lab=#net95}
N 13240 200 13575 200 {
lab=A2}
N 13575 200 13575 490 {
lab=A2}
N 13240 180 13605 180 {
lab=#net95}
N 13605 180 13605 470 {
lab=#net95}
N 13300 290 13630 290 {
lab=#net92}
N 12400 440 12460 440 {
lab=#net96}
N 12460 280 12460 440 {
lab=#net96}
N 12460 270 12460 280 {
lab=#net96}
N 12400 270 12460 270 {
lab=#net96}
N 12400 250 12490 250 {
lab=#net97}
N 12040 220 12080 220 {
lab=#net98}
N 12200 450 12260 450 {
lab=S19}
N 12690 470 12795 470 {
lab=A3}
N 12690 450 12795 450 {
lab=#net99}
N 12400 180 12735 180 {
lab=A3}
N 12735 180 12735 470 {
lab=A3}
N 12400 160 12765 160 {
lab=#net99}
N 12765 160 12765 450 {
lab=#net99}
N 12460 270 12790 270 {
lab=#net96}
N 14930 -180 14930 180 {
lab=#net80}
N 13640 -180 14930 -180 {
lab=#net80}
N 13640 -320 13640 -180 {
lab=#net80}
N 15100 -210 15100 260 {
lab=#net81}
N 13800 -210 15100 -210 {
lab=#net81}
N 13800 -320 13800 -210 {
lab=#net81}
N 14240 -240 14240 260 {
lab=#net87}
N 13790 -240 14240 -240 {
lab=#net87}
N 13780 -240 13790 -240 {
lab=#net87}
N 13780 -320 13780 -240 {
lab=#net87}
N 14040 -150 14040 180 {
lab=#net85}
N 13670 -150 14040 -150 {
lab=#net85}
N 13660 -150 13670 -150 {
lab=#net85}
N 13660 -320 13660 -150 {
lab=#net85}
N 13760 -320 13760 -70 {
lab=#net93}
N 13330 -70 13760 -70 {
lab=#net93}
N 13330 -70 13330 270 {
lab=#net93}
N 13160 -240 13160 190 {
lab=#net91}
N 13160 -240 13680 -240 {
lab=#net91}
N 13680 -320 13680 -240 {
lab=#net91}
N 12490 -280 12490 250 {
lab=#net97}
N 12490 -280 13740 -280 {
lab=#net97}
N 13740 -320 13740 -280 {
lab=#net97}
N 15400 280 15430 280 {
lab=#net76}
N 14540 -510 14540 280 {
lab=#net86}
N 13550 -510 14540 -510 {
lab=#net86}
N 13550 -510 13550 -370 {
lab=#net86}
N 13550 -370 13590 -370 {
lab=#net86}
N 13630 -30 13630 290 {
lab=#net92}
N 13470 -30 13630 -30 {
lab=#net92}
N 13470 -390 13470 -30 {
lab=#net92}
N 13470 -390 13590 -390 {
lab=#net92}
N 12780 -410 13590 -410 {
lab=#net96}
N 12780 -410 12780 270 {
lab=#net96}
N 13530 -430 13590 -430 {
lab=#net100}
N 12210 230 12270 230 {
lab=#net101}
N 12270 230 12270 260 {
lab=#net101}
N 12270 260 12320 260 {
lab=#net101}
N 12400 460 12550 460 {
lab=#net97}
N 12490 250 12490 460 {
lab=#net97}
N 12210 210 12270 210 {
lab=#net102}
N 12270 170 12270 210 {
lab=#net102}
N 12270 170 12320 170 {
lab=#net102}
N 12270 -300 12270 170 {
lab=#net102}
N 12270 -300 13700 -300 {
lab=#net102}
N 13700 -320 13700 -300 {
lab=#net102}
N 15610 560 15630 560 {
lab=B0}
N 15380 570 15470 570 {
lab=#net83}
N 15380 460 15380 570 {
lab=#net83}
N 14660 560 14700 560 {
lab=B1}
N 14520 460 14520 570 {
lab=#net89}
N 13620 570 13640 570 {
lab=#net95}
N 13620 470 13620 570 {
lab=#net95}
N 13780 560 13810 560 {
lab=B2}
N 12770 560 12800 560 {
lab=#net99}
N 12770 450 12770 560 {
lab=#net99}
N 12940 550 12970 550 {
lab=B3}
N 12940 570 13020 570 {
lab=Cin}
N 13020 570 13020 640 {
lab=Cin}
N 13020 640 13810 640 {
lab=Cin}
N 13810 580 13810 640 {
lab=Cin}
N 13780 580 13810 580 {
lab=Cin}
N 13810 640 14740 640 {
lab=Cin}
N 14740 590 14740 640 {
lab=Cin}
N 14740 580 14740 590 {
lab=Cin}
N 14660 580 14740 580 {
lab=Cin}
N 14740 640 15640 640 {
lab=Cin}
N 15640 580 15640 640 {
lab=Cin}
N 15610 580 15640 580 {
lab=Cin}
N 15640 640 15730 640 {
lab=Cin}
N 15730 360 15730 640 {
lab=Cin}
N 11150 250 11150 280 {
lab=#net103}
N 11090 250 11150 250 {
lab=#net103}
N 11150 190 11150 230 {
lab=#net104}
N 11090 230 11150 230 {
lab=#net104}
N 11280 460 11340 460 {
lab=#net100}
N 11340 300 11340 460 {
lab=#net100}
N 11340 290 11340 300 {
lab=#net100}
N 11280 290 11340 290 {
lab=#net100}
N 11280 270 11370 270 {
lab=#net105}
N 11370 270 11370 480 {
lab=#net105}
N 11280 480 11370 480 {
lab=#net105}
N 11370 480 11430 480 {
lab=#net105}
N 11150 280 11200 280 {
lab=#net103}
N 11150 190 11200 190 {
lab=#net104}
N 10920 240 10960 240 {
lab=#net106}
N 11080 470 11140 470 {
lab=S20}
N 11570 490 11675 490 {
lab=A0}
N 11570 470 11675 470 {
lab=#net107}
N 11280 200 11615 200 {
lab=A0}
N 11615 200 11615 490 {
lab=A0}
N 11280 180 11645 180 {
lab=#net107}
N 11645 180 11645 470 {
lab=#net107}
N 11340 290 11670 290 {
lab=#net100}
N 10290 250 10290 280 {
lab=#net108}
N 10230 250 10290 250 {
lab=#net108}
N 10290 190 10290 230 {
lab=#net109}
N 10230 230 10290 230 {
lab=#net109}
N 10420 460 10480 460 {
lab=#net110}
N 10480 300 10480 460 {
lab=#net110}
N 10480 290 10480 300 {
lab=#net110}
N 10420 290 10480 290 {
lab=#net110}
N 10420 270 10510 270 {
lab=#net111}
N 10510 270 10510 480 {
lab=#net111}
N 10420 480 10510 480 {
lab=#net111}
N 10510 480 10570 480 {
lab=#net111}
N 10290 280 10340 280 {
lab=#net108}
N 10290 190 10340 190 {
lab=#net109}
N 10060 240 10100 240 {
lab=#net112}
N 10220 470 10280 470 {
lab=S21}
N 10710 490 10815 490 {
lab=A1}
N 10710 470 10815 470 {
lab=#net113}
N 10420 200 10755 200 {
lab=A1}
N 10755 200 10755 490 {
lab=A1}
N 10420 180 10785 180 {
lab=#net113}
N 10785 180 10785 470 {
lab=#net113}
N 10480 290 10810 290 {
lab=#net110}
N 9380 260 9380 290 {
lab=#net114}
N 9320 260 9380 260 {
lab=#net114}
N 9380 200 9380 240 {
lab=#net115}
N 9320 240 9380 240 {
lab=#net115}
N 9510 470 9570 470 {
lab=#net116}
N 9570 310 9570 470 {
lab=#net116}
N 9570 300 9570 310 {
lab=#net116}
N 9510 300 9570 300 {
lab=#net116}
N 9510 280 9600 280 {
lab=#net117}
N 9600 280 9600 490 {
lab=#net117}
N 9510 490 9600 490 {
lab=#net117}
N 9600 490 9660 490 {
lab=#net117}
N 9380 290 9430 290 {
lab=#net114}
N 9380 200 9430 200 {
lab=#net115}
N 9150 250 9190 250 {
lab=#net118}
N 9310 480 9370 480 {
lab=S22}
N 9800 500 9905 500 {
lab=A2}
N 9800 480 9905 480 {
lab=#net119}
N 9510 210 9845 210 {
lab=A2}
N 9845 210 9845 500 {
lab=A2}
N 9510 190 9875 190 {
lab=#net119}
N 9875 190 9875 480 {
lab=#net119}
N 9570 300 9900 300 {
lab=#net116}
N 8670 450 8730 450 {
lab=C3}
N 8730 290 8730 450 {
lab=C3}
N 8730 280 8730 290 {
lab=C3}
N 8670 280 8730 280 {
lab=C3}
N 8670 260 8760 260 {
lab=#net120}
N 8310 230 8350 230 {
lab=#net121}
N 8470 460 8530 460 {
lab=S23}
N 8960 480 9065 480 {
lab=A3}
N 8960 460 9065 460 {
lab=#net122}
N 8670 190 9005 190 {
lab=A3}
N 9005 190 9005 480 {
lab=A3}
N 8670 170 9035 170 {
lab=#net122}
N 9035 170 9035 460 {
lab=#net122}
N 8730 280 9060 280 {
lab=C3}
N 11200 -170 11200 190 {
lab=#net104}
N 9910 -170 11200 -170 {
lab=#net104}
N 9910 -310 9910 -170 {
lab=#net104}
N 11370 -200 11370 270 {
lab=#net105}
N 10070 -200 11370 -200 {
lab=#net105}
N 10070 -310 10070 -200 {
lab=#net105}
N 10510 -230 10510 270 {
lab=#net111}
N 10060 -230 10510 -230 {
lab=#net111}
N 10050 -230 10060 -230 {
lab=#net111}
N 10050 -310 10050 -230 {
lab=#net111}
N 10310 -140 10310 190 {
lab=#net109}
N 9940 -140 10310 -140 {
lab=#net109}
N 9930 -140 9940 -140 {
lab=#net109}
N 9930 -310 9930 -140 {
lab=#net109}
N 10030 -310 10030 -60 {
lab=#net117}
N 9600 -60 10030 -60 {
lab=#net117}
N 9600 -60 9600 280 {
lab=#net117}
N 9430 -230 9430 200 {
lab=#net115}
N 9430 -230 9950 -230 {
lab=#net115}
N 9950 -310 9950 -230 {
lab=#net115}
N 8760 -270 8760 260 {
lab=#net120}
N 8760 -270 10010 -270 {
lab=#net120}
N 10010 -310 10010 -270 {
lab=#net120}
N 11670 290 11700 290 {
lab=#net100}
N 10810 -500 10810 290 {
lab=#net110}
N 9820 -500 10810 -500 {
lab=#net110}
N 9820 -500 9820 -360 {
lab=#net110}
N 9820 -360 9860 -360 {
lab=#net110}
N 9900 -20 9900 300 {
lab=#net116}
N 9740 -20 9900 -20 {
lab=#net116}
N 9740 -380 9740 -20 {
lab=#net116}
N 9740 -380 9860 -380 {
lab=#net116}
N 9050 -400 9860 -400 {
lab=C3}
N 9050 -400 9050 280 {
lab=C3}
N 9800 -420 9860 -420 {
lab=#net123}
N 8480 240 8540 240 {
lab=#net124}
N 8540 240 8540 270 {
lab=#net124}
N 8540 270 8590 270 {
lab=#net124}
N 8670 470 8820 470 {
lab=#net120}
N 8760 260 8760 470 {
lab=#net120}
N 8480 220 8540 220 {
lab=#net125}
N 8540 180 8540 220 {
lab=#net125}
N 8540 180 8590 180 {
lab=#net125}
N 8540 -290 8540 180 {
lab=#net125}
N 8540 -290 9970 -290 {
lab=#net125}
N 9970 -310 9970 -290 {
lab=#net125}
N 11880 570 11900 570 {
lab=B0}
N 11650 580 11740 580 {
lab=#net107}
N 11650 470 11650 580 {
lab=#net107}
N 10930 570 10970 570 {
lab=B1}
N 10790 470 10790 580 {
lab=#net113}
N 9890 580 9910 580 {
lab=#net119}
N 9890 480 9890 580 {
lab=#net119}
N 10050 570 10080 570 {
lab=B2}
N 9040 570 9070 570 {
lab=#net122}
N 9040 460 9040 570 {
lab=#net122}
N 9210 560 9240 560 {
lab=B3}
N 9210 580 9290 580 {
lab=Cin}
N 9290 580 9290 650 {
lab=Cin}
N 9290 650 10080 650 {
lab=Cin}
N 10080 590 10080 650 {
lab=Cin}
N 10050 590 10080 590 {
lab=Cin}
N 10080 650 11010 650 {
lab=Cin}
N 11010 600 11010 650 {
lab=Cin}
N 11010 590 11010 600 {
lab=Cin}
N 10930 590 11010 590 {
lab=Cin}
N 11010 650 11910 650 {
lab=Cin}
N 11910 590 11910 650 {
lab=Cin}
N 11880 590 11910 590 {
lab=Cin}
N 11910 650 12000 650 {
lab=Cin}
N 11820 -430 13530 -430 {
lab=#net100}
N 11820 -430 11820 290 {
lab=#net100}
N 11700 290 11820 290 {
lab=#net100}
N 11990 650 13020 650 {
lab=Cin}
N 13020 630 13020 650 {
lab=Cin}
N 10130 -380 11820 -380 {
lab=#net100}
N 7310 260 7310 290 {
lab=#net126}
N 7250 260 7310 260 {
lab=#net126}
N 7310 200 7310 240 {
lab=#net127}
N 7250 240 7310 240 {
lab=#net127}
N 7440 470 7500 470 {
lab=#net123}
N 7500 310 7500 470 {
lab=#net123}
N 7500 300 7500 310 {
lab=#net123}
N 7440 300 7500 300 {
lab=#net123}
N 7440 280 7530 280 {
lab=#net128}
N 7530 280 7530 490 {
lab=#net128}
N 7440 490 7530 490 {
lab=#net128}
N 7530 490 7590 490 {
lab=#net128}
N 7310 290 7360 290 {
lab=#net126}
N 7310 200 7360 200 {
lab=#net127}
N 7080 250 7120 250 {
lab=#net129}
N 7240 480 7300 480 {
lab=S24}
N 7730 500 7835 500 {
lab=A0}
N 7730 480 7835 480 {
lab=#net130}
N 7440 210 7775 210 {
lab=A0}
N 7775 210 7775 500 {
lab=A0}
N 7440 190 7805 190 {
lab=#net130}
N 7805 190 7805 480 {
lab=#net130}
N 7500 300 7830 300 {
lab=#net123}
N 6450 260 6450 290 {
lab=#net131}
N 6390 260 6450 260 {
lab=#net131}
N 6450 200 6450 240 {
lab=#net132}
N 6390 240 6450 240 {
lab=#net132}
N 6580 470 6640 470 {
lab=#net133}
N 6640 310 6640 470 {
lab=#net133}
N 6640 300 6640 310 {
lab=#net133}
N 6580 300 6640 300 {
lab=#net133}
N 6580 280 6670 280 {
lab=#net134}
N 6670 280 6670 490 {
lab=#net134}
N 6580 490 6670 490 {
lab=#net134}
N 6670 490 6730 490 {
lab=#net134}
N 6450 290 6500 290 {
lab=#net131}
N 6450 200 6500 200 {
lab=#net132}
N 6220 250 6260 250 {
lab=#net135}
N 6380 480 6440 480 {
lab=S25}
N 6870 500 6975 500 {
lab=A1}
N 6870 480 6975 480 {
lab=#net136}
N 6580 210 6915 210 {
lab=A1}
N 6915 210 6915 500 {
lab=A1}
N 6580 190 6945 190 {
lab=#net136}
N 6945 190 6945 480 {
lab=#net136}
N 6640 300 6970 300 {
lab=#net133}
N 5540 270 5540 300 {
lab=#net137}
N 5480 270 5540 270 {
lab=#net137}
N 5540 210 5540 250 {
lab=#net138}
N 5480 250 5540 250 {
lab=#net138}
N 5670 480 5730 480 {
lab=#net139}
N 5730 320 5730 480 {
lab=#net139}
N 5730 310 5730 320 {
lab=#net139}
N 5670 310 5730 310 {
lab=#net139}
N 5670 290 5760 290 {
lab=#net140}
N 5760 290 5760 500 {
lab=#net140}
N 5670 500 5760 500 {
lab=#net140}
N 5760 500 5820 500 {
lab=#net140}
N 5540 300 5590 300 {
lab=#net137}
N 5540 210 5590 210 {
lab=#net138}
N 5310 260 5350 260 {
lab=#net141}
N 5470 490 5530 490 {
lab=S26}
N 5960 510 6065 510 {
lab=A2}
N 5960 490 6065 490 {
lab=#net142}
N 5670 220 6005 220 {
lab=A2}
N 6005 220 6005 510 {
lab=A2}
N 5670 200 6035 200 {
lab=#net142}
N 6035 200 6035 490 {
lab=#net142}
N 5730 310 6060 310 {
lab=#net139}
N 4830 460 4890 460 {
lab=#net143}
N 4890 300 4890 460 {
lab=#net143}
N 4890 290 4890 300 {
lab=#net143}
N 4830 290 4890 290 {
lab=#net143}
N 4830 270 4920 270 {
lab=#net144}
N 4470 240 4510 240 {
lab=#net145}
N 4630 470 4690 470 {
lab=S27}
N 5120 490 5225 490 {
lab=A3}
N 5120 470 5225 470 {
lab=#net146}
N 4830 200 5165 200 {
lab=A3}
N 5165 200 5165 490 {
lab=A3}
N 4830 180 5195 180 {
lab=#net146}
N 5195 180 5195 470 {
lab=#net146}
N 4890 290 5220 290 {
lab=#net143}
N 7360 -160 7360 200 {
lab=#net127}
N 6070 -160 7360 -160 {
lab=#net127}
N 6070 -300 6070 -160 {
lab=#net127}
N 7530 -190 7530 280 {
lab=#net128}
N 6230 -190 7530 -190 {
lab=#net128}
N 6230 -300 6230 -190 {
lab=#net128}
N 6670 -220 6670 280 {
lab=#net134}
N 6220 -220 6670 -220 {
lab=#net134}
N 6210 -220 6220 -220 {
lab=#net134}
N 6210 -300 6210 -220 {
lab=#net134}
N 6470 -130 6470 200 {
lab=#net132}
N 6100 -130 6470 -130 {
lab=#net132}
N 6090 -130 6100 -130 {
lab=#net132}
N 6090 -300 6090 -130 {
lab=#net132}
N 6190 -300 6190 -50 {
lab=#net140}
N 5760 -50 6190 -50 {
lab=#net140}
N 5760 -50 5760 290 {
lab=#net140}
N 5590 -220 5590 210 {
lab=#net138}
N 5590 -220 6110 -220 {
lab=#net138}
N 6110 -300 6110 -220 {
lab=#net138}
N 4920 -260 4920 270 {
lab=#net144}
N 4920 -260 6170 -260 {
lab=#net144}
N 6170 -300 6170 -260 {
lab=#net144}
N 6290 -370 7860 -370 {
lab=#net123}
N 7830 300 7860 300 {
lab=#net123}
N 6970 -490 6970 300 {
lab=#net133}
N 5980 -490 6970 -490 {
lab=#net133}
N 5980 -490 5980 -350 {
lab=#net133}
N 5980 -350 6020 -350 {
lab=#net133}
N 6060 -10 6060 310 {
lab=#net139}
N 5900 -10 6060 -10 {
lab=#net139}
N 5900 -370 5900 -10 {
lab=#net139}
N 5900 -370 6020 -370 {
lab=#net139}
N 5210 -390 6020 -390 {
lab=#net143}
N 5210 -390 5210 290 {
lab=#net143}
N 5960 -410 6020 -410 {
lab=#net147}
N 4640 250 4700 250 {
lab=#net148}
N 4700 250 4700 280 {
lab=#net148}
N 4700 280 4750 280 {
lab=#net148}
N 4830 480 4980 480 {
lab=#net144}
N 4920 270 4920 480 {
lab=#net144}
N 4640 230 4700 230 {
lab=#net149}
N 4700 190 4700 230 {
lab=#net149}
N 4700 190 4750 190 {
lab=#net149}
N 4700 -280 4700 190 {
lab=#net149}
N 4700 -280 6130 -280 {
lab=#net149}
N 6130 -300 6130 -280 {
lab=#net149}
N 8040 580 8060 580 {
lab=B0}
N 7810 590 7900 590 {
lab=#net130}
N 7810 480 7810 590 {
lab=#net130}
N 7090 580 7130 580 {
lab=B1}
N 6950 480 6950 590 {
lab=#net136}
N 6050 590 6070 590 {
lab=#net142}
N 6050 490 6050 590 {
lab=#net142}
N 6210 580 6240 580 {
lab=B2}
N 5200 580 5230 580 {
lab=#net146}
N 5200 470 5200 580 {
lab=#net146}
N 5370 570 5400 570 {
lab=B3}
N 5370 590 5450 590 {
lab=Cin}
N 5450 590 5450 660 {
lab=Cin}
N 5450 660 6240 660 {
lab=Cin}
N 6240 600 6240 660 {
lab=Cin}
N 6210 600 6240 600 {
lab=Cin}
N 6240 660 7170 660 {
lab=Cin}
N 7170 610 7170 660 {
lab=Cin}
N 7170 600 7170 610 {
lab=Cin}
N 7090 600 7170 600 {
lab=Cin}
N 7170 660 8070 660 {
lab=Cin}
N 8070 600 8070 660 {
lab=Cin}
N 8040 600 8070 600 {
lab=Cin}
N 8070 660 8160 660 {
lab=Cin}
N 3580 270 3580 300 {
lab=#net150}
N 3520 270 3580 270 {
lab=#net150}
N 3580 210 3580 250 {
lab=#net151}
N 3520 250 3580 250 {
lab=#net151}
N 3710 480 3770 480 {
lab=#net147}
N 3770 320 3770 480 {
lab=#net147}
N 3770 310 3770 320 {
lab=#net147}
N 3710 310 3770 310 {
lab=#net147}
N 3710 290 3800 290 {
lab=#net152}
N 3800 290 3800 500 {
lab=#net152}
N 3710 500 3800 500 {
lab=#net152}
N 3800 500 3860 500 {
lab=#net152}
N 3580 300 3630 300 {
lab=#net150}
N 3580 210 3630 210 {
lab=#net151}
N 3350 260 3390 260 {
lab=#net153}
N 3510 490 3570 490 {
lab=S28}
N 4000 510 4105 510 {
lab=A0}
N 4000 490 4105 490 {
lab=#net154}
N 3710 220 4045 220 {
lab=A0}
N 4045 220 4045 510 {
lab=A0}
N 3710 200 4075 200 {
lab=#net154}
N 4075 200 4075 490 {
lab=#net154}
N 3770 310 4100 310 {
lab=#net147}
N 2720 270 2720 300 {
lab=#net155}
N 2660 270 2720 270 {
lab=#net155}
N 2720 210 2720 250 {
lab=#net156}
N 2660 250 2720 250 {
lab=#net156}
N 2850 480 2910 480 {
lab=#net157}
N 2910 320 2910 480 {
lab=#net157}
N 2910 310 2910 320 {
lab=#net157}
N 2850 310 2910 310 {
lab=#net157}
N 2850 290 2940 290 {
lab=#net158}
N 2940 290 2940 500 {
lab=#net158}
N 2850 500 2940 500 {
lab=#net158}
N 2940 500 3000 500 {
lab=#net158}
N 2720 300 2770 300 {
lab=#net155}
N 2720 210 2770 210 {
lab=#net156}
N 2490 260 2530 260 {
lab=#net159}
N 2650 490 2710 490 {
lab=S29}
N 3140 510 3245 510 {
lab=A1}
N 3140 490 3245 490 {
lab=#net160}
N 2850 220 3185 220 {
lab=A1}
N 3185 220 3185 510 {
lab=A1}
N 2850 200 3215 200 {
lab=#net160}
N 3215 200 3215 490 {
lab=#net160}
N 2910 310 3240 310 {
lab=#net157}
N 1810 280 1810 310 {
lab=#net161}
N 1750 280 1810 280 {
lab=#net161}
N 1810 220 1810 260 {
lab=#net162}
N 1750 260 1810 260 {
lab=#net162}
N 1940 490 2000 490 {
lab=#net163}
N 2000 330 2000 490 {
lab=#net163}
N 2000 320 2000 330 {
lab=#net163}
N 1940 320 2000 320 {
lab=#net163}
N 1940 300 2030 300 {
lab=#net164}
N 2030 300 2030 510 {
lab=#net164}
N 1940 510 2030 510 {
lab=#net164}
N 2030 510 2090 510 {
lab=#net164}
N 1810 310 1860 310 {
lab=#net161}
N 1810 220 1860 220 {
lab=#net162}
N 1580 270 1620 270 {
lab=#net165}
N 1740 500 1800 500 {
lab=S30}
N 2230 520 2335 520 {
lab=A2}
N 2230 500 2335 500 {
lab=#net166}
N 1940 230 2275 230 {
lab=A2}
N 2275 230 2275 520 {
lab=A2}
N 1940 210 2305 210 {
lab=#net166}
N 2305 210 2305 500 {
lab=#net166}
N 2000 320 2330 320 {
lab=#net163}
N 1100 470 1160 470 {
lab=#net167}
N 1160 310 1160 470 {
lab=#net167}
N 1160 300 1160 310 {
lab=#net167}
N 1100 300 1160 300 {
lab=#net167}
N 1100 280 1190 280 {
lab=#net168}
N 900 480 960 480 {
lab=S31}
N 1390 500 1495 500 {
lab=A3}
N 1390 480 1495 480 {
lab=#net169}
N 1100 210 1435 210 {
lab=A3}
N 1435 210 1435 500 {
lab=A3}
N 1100 190 1465 190 {
lab=#net169}
N 1465 190 1465 480 {
lab=#net169}
N 1160 300 1490 300 {
lab=#net167}
N 3630 -150 3630 210 {
lab=#net151}
N 2340 -150 3630 -150 {
lab=#net151}
N 2340 -290 2340 -150 {
lab=#net151}
N 3800 -180 3800 290 {
lab=#net152}
N 2500 -180 3800 -180 {
lab=#net152}
N 2500 -290 2500 -180 {
lab=#net152}
N 2940 -210 2940 290 {
lab=#net158}
N 2490 -210 2940 -210 {
lab=#net158}
N 2480 -210 2490 -210 {
lab=#net158}
N 2480 -290 2480 -210 {
lab=#net158}
N 2740 -120 2740 210 {
lab=#net156}
N 2370 -120 2740 -120 {
lab=#net156}
N 2360 -120 2370 -120 {
lab=#net156}
N 2360 -290 2360 -120 {
lab=#net156}
N 2460 -290 2460 -40 {
lab=#net164}
N 2030 -40 2460 -40 {
lab=#net164}
N 2030 -40 2030 300 {
lab=#net164}
N 1860 -210 1860 220 {
lab=#net162}
N 1860 -210 2380 -210 {
lab=#net162}
N 2380 -290 2380 -210 {
lab=#net162}
N 1190 -250 1190 280 {
lab=#net168}
N 1190 -250 2440 -250 {
lab=#net168}
N 2440 -290 2440 -250 {
lab=#net168}
N 4100 310 4130 310 {
lab=#net147}
N 3240 -480 3240 310 {
lab=#net157}
N 2250 -480 3240 -480 {
lab=#net157}
N 2250 -480 2250 -340 {
lab=#net157}
N 2250 -340 2290 -340 {
lab=#net157}
N 2330 0 2330 320 {
lab=#net163}
N 2170 0 2330 0 {
lab=#net163}
N 2170 -360 2170 0 {
lab=#net163}
N 2170 -360 2290 -360 {
lab=#net163}
N 1480 -380 2290 -380 {
lab=#net167}
N 1480 -380 1480 300 {
lab=#net167}
N 2230 -400 2290 -400 {
lab=Cout}
N 910 260 970 260 {
lab=#net170}
N 970 260 970 290 {
lab=#net170}
N 970 290 1020 290 {
lab=#net170}
N 1100 490 1250 490 {
lab=#net168}
N 1190 280 1190 490 {
lab=#net168}
N 910 240 970 240 {
lab=#net171}
N 970 200 970 240 {
lab=#net171}
N 970 200 1020 200 {
lab=#net171}
N 970 -270 970 200 {
lab=#net171}
N 970 -270 2400 -270 {
lab=#net171}
N 2400 -290 2400 -270 {
lab=#net171}
N 4310 590 4330 590 {
lab=B0}
N 4080 600 4170 600 {
lab=#net154}
N 4080 490 4080 600 {
lab=#net154}
N 3360 590 3400 590 {
lab=B1}
N 3220 490 3220 600 {
lab=#net160}
N 2320 600 2340 600 {
lab=#net166}
N 2320 500 2320 600 {
lab=#net166}
N 2480 590 2510 590 {
lab=B2}
N 1470 590 1500 590 {
lab=#net169}
N 1470 480 1470 590 {
lab=#net169}
N 1640 580 1670 580 {
lab=B3}
N 1640 600 1720 600 {
lab=Cin}
N 1720 600 1720 670 {
lab=Cin}
N 1720 670 2510 670 {
lab=Cin}
N 2510 610 2510 670 {
lab=Cin}
N 2480 610 2510 610 {
lab=Cin}
N 2510 670 3440 670 {
lab=Cin}
N 3440 620 3440 670 {
lab=Cin}
N 3440 610 3440 620 {
lab=Cin}
N 3360 610 3440 610 {
lab=Cin}
N 3440 670 4340 670 {
lab=Cin}
N 4340 610 4340 670 {
lab=Cin}
N 4310 610 4340 610 {
lab=Cin}
N 4340 670 4430 670 {
lab=Cin}
N 4250 -410 5960 -410 {
lab=#net147}
N 4250 -410 4250 310 {
lab=#net147}
N 4130 310 4250 310 {
lab=#net147}
N 4420 670 5450 670 {
lab=Cin}
N 5450 650 5450 670 {
lab=Cin}
N 2560 -360 4250 -360 {
lab=#net147}
N 8160 660 9300 660 {
lab=Cin}
N 9300 650 9300 660 {
lab=Cin}
N 7860 -420 9800 -420 {
lab=#net123}
N 7860 -420 7860 -370 {
lab=#net123}
N 7860 -370 7860 300 {
lab=#net123}
N 14500 -800 14500 -380 {
lab=#net76}
N 13860 -380 14500 -380 {
lab=#net76}
N 13860 -390 13860 -380 {
lab=#net76}
N 15430 -380 15430 280 {
lab=#net76}
N 14500 -380 15430 -380 {
lab=#net76}
N 15010 -1860 16010 -1860 {
lab=Cin}
N 16010 -1860 16010 250 {
lab=Cin}
N 15730 250 16010 250 {
lab=Cin}
N 15730 250 15730 380 {
lab=Cin}
C {XOR2.sym} 1490 -1670 0 0 {name=x1}
C {XOR2.sym} 1780 -1660 0 0 {name=x2}
C {OR2.sym} 1960 -1430 0 0 {name=x3}
C {AND2.sym} 1760 -1470 0 0 {name=x4}
C {AND2.sym} 1760 -1380 0 0 {name=x5}
C {devices/opin.sym} 1920 -1660 0 0 {name=p4 lab=S0}
C {devices/lab_pin.sym} 2080 -1430 2 0 {name=p5 lab=Co1}
C {devices/ipin.sym} 1325 -1680 0 0 {name=p1 sig_type=std_logic lab=A0}
C {devices/ipin.sym} 1105 -1760 0 0 {name=p2 sig_type=std_logic lab=B0}
C {devices/ipin.sym} 1300 -1480 0 0 {name=p3 sig_type=std_logic lab=Cin}
C {XOR2.sym} 2350 -1670 0 0 {name=x6}
C {XOR2.sym} 2640 -1660 0 0 {name=x7}
C {OR2.sym} 2820 -1430 0 0 {name=x8}
C {AND2.sym} 2620 -1470 0 0 {name=x9}
C {AND2.sym} 2620 -1380 0 0 {name=x10}
C {devices/opin.sym} 2780 -1660 0 0 {name=p8 lab=S1}
C {devices/ipin.sym} 2185 -1680 0 0 {name=p10 sig_type=std_logic lab=A1}
C {devices/ipin.sym} 2035 -1760 0 0 {name=p11 sig_type=std_logic lab=B1}
C {XOR2.sym} 3260 -1680 0 0 {name=x11}
C {XOR2.sym} 3550 -1670 0 0 {name=x12}
C {OR2.sym} 3730 -1440 0 0 {name=x13}
C {AND2.sym} 3530 -1480 0 0 {name=x14}
C {AND2.sym} 3530 -1390 0 0 {name=x15}
C {devices/opin.sym} 3690 -1670 0 0 {name=p17 lab=S2}
C {devices/ipin.sym} 3095 -1690 0 0 {name=p19 sig_type=std_logic lab=A2}
C {devices/ipin.sym} 2925 -1760 0 0 {name=p20 sig_type=std_logic lab=B2}
C {XOR2.sym} 4100 -1660 0 0 {name=x16}
C {XOR2.sym} 4390 -1650 0 0 {name=x17}
C {OR2.sym} 4570 -1420 0 0 {name=x18}
C {AND2.sym} 4370 -1460 0 0 {name=x19}
C {AND2.sym} 4370 -1370 0 0 {name=x20}
C {devices/opin.sym} 4530 -1650 0 0 {name=p24 lab=S3}
C {devices/ipin.sym} 3935 -1670 0 0 {name=p26 sig_type=std_logic lab=A3}
C {devices/ipin.sym} 3765 -1750 0 0 {name=p27 sig_type=std_logic lab=B3}
C {4_BIT_CLA_Carry_logic.sym} 2990 -780 0 0 {name=x21}
C {devices/lab_pin.sym} 2940 -1430 2 0 {name=p9 lab=Co2}
C {devices/lab_pin.sym} 3850 -1440 2 0 {name=p12 lab=Co3}
C {devices/lab_pin.sym} 4690 -1420 2 0 {name=p13 lab=Co4}
C {XOR2.sym} 1180 -1770 0 0 {name=x22}
C {XOR2.sym} 2130 -1770 0 0 {name=x23}
C {XOR2.sym} 3010 -1770 0 0 {name=x24}
C {XOR2.sym} 3850 -1760 0 0 {name=x25}
C {devices/vsource.sym} 3458 -2468 0 0 {name=VA4 value="pwl=0 1.8 50n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 3458 -2498 0 0 {name=p38 sig_type=std_logic lab=A3}
C {devices/vsource.sym} 3458 -2368 0 0 {name=VA5 value="pwl=0 1.8 50n 1.8 " savecurrent=false}
C {devices/lab_pin.sym} 3458 -2398 0 0 {name=p39 sig_type=std_logic lab=A2}
C {devices/vsource.sym} 3458 -2268 0 0 {name=VA6 value="pwl=0 0 50n 0 " savecurrent=false}
C {devices/lab_pin.sym} 3458 -2298 0 0 {name=p40 sig_type=std_logic lab=A1}
C {devices/vsource.sym} 3458 -2168 0 0 {name=VA0 value="pwl=0 1.8 50n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 3458 -2198 0 0 {name=VA7 sig_type=std_logic lab=A0}
C {devices/vsource.sym} 3238 -2478 0 0 {name=VB5 value="pwl=0 1.8 50n 1.8 " savecurrent=false}
C {devices/lab_pin.sym} 3238 -2508 0 0 {name=VB4 sig_type=std_logic lab=B3}
C {devices/vsource.sym} 3238 -2378 0 0 {name=VB6 value="pwl=0 1.8 50n 1.8 " savecurrent=false}
C {devices/lab_pin.sym} 3238 -2408 0 0 {name=VB7 sig_type=std_logic lab=B2}
C {devices/vsource.sym} 3238 -2278 0 0 {name=VB8 value="pwl=0 1.8 50n 1.8 " savecurrent=false}
C {devices/lab_pin.sym} 3238 -2308 0 0 {name=VB9 sig_type=std_logic lab=B1}
C {devices/vsource.sym} 3238 -2178 0 0 {name=VB0 value="pwl=0 1.8 50n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 3238 -2208 0 0 {name=VB10 sig_type=std_logic lab=B0}
C {devices/gnd.sym} 3458 -2138 0 0 {name=l7 lab=GND}
C {devices/gnd.sym} 3238 -2148 0 0 {name=l8 lab=GND}
C {devices/gnd.sym} 3458 -2238 0 0 {name=l15 lab=GND}
C {devices/gnd.sym} 3238 -2248 0 0 {name=l16 lab=GND}
C {devices/gnd.sym} 3458 -2338 0 0 {name=l17 lab=GND}
C {devices/gnd.sym} 3238 -2348 0 0 {name=l18 lab=GND}
C {devices/gnd.sym} 3238 -2448 0 0 {name=l19 lab=GND}
C {devices/gnd.sym} 3458 -2438 0 0 {name=l20 lab=GND}
C {devices/vsource.sym} 3458 -2048 0 0 {name=VCi value="pwl=0 1.8 50n 1.8 " savecurrent=false}
C {devices/lab_pin.sym} 3458 -2078 0 0 {name=Ci1 sig_type=std_logic lab=Cin}
C {devices/gnd.sym} 3458 -2018 0 0 {name=Ci2 lab=GND}
C {devices/vsource.sym} 3238 -2058 0 0 {name=VDD1 value=1.8 savecurrent=false}
C {devices/lab_pin.sym} 3238 -2088 0 0 {name=Ci3 sig_type=std_logic lab=Vdd}
C {devices/gnd.sym} 3238 -2028 0 0 {name=Ci4 lab=GND}
C {devices/code_shown.sym} 2177 -2320 0 0 {name=S1 only_toplevel=false value=".tran 0.01n 100n
.save all"}
C {sky130_fd_pr/corner.sym} 1972 -2130 0 0 {name=CORNER only_toplevel=true corner=tt}
C {XOR2.sym} 5220 -1680 0 0 {name=x26}
C {XOR2.sym} 5510 -1670 0 0 {name=x27}
C {OR2.sym} 5690 -1440 0 0 {name=x28}
C {AND2.sym} 5490 -1480 0 0 {name=x29}
C {AND2.sym} 5490 -1390 0 0 {name=x30}
C {devices/opin.sym} 5650 -1670 0 0 {name=p6 lab=S4}
C {devices/lab_pin.sym} 5810 -1440 2 0 {name=p7 lab=Co5}
C {devices/ipin.sym} 5055 -1690 0 0 {name=p15 sig_type=std_logic lab=A0}
C {devices/ipin.sym} 4835 -1770 0 0 {name=p16 sig_type=std_logic lab=B0}
C {XOR2.sym} 6080 -1680 0 0 {name=x31}
C {XOR2.sym} 6370 -1670 0 0 {name=x32}
C {OR2.sym} 6550 -1440 0 0 {name=x33}
C {AND2.sym} 6350 -1480 0 0 {name=x34}
C {AND2.sym} 6350 -1390 0 0 {name=x35}
C {devices/opin.sym} 6510 -1670 0 0 {name=p22 lab=S5}
C {devices/ipin.sym} 5915 -1690 0 0 {name=p23 sig_type=std_logic lab=A1}
C {devices/ipin.sym} 5765 -1770 0 0 {name=p25 sig_type=std_logic lab=B1}
C {XOR2.sym} 6990 -1690 0 0 {name=x36}
C {XOR2.sym} 7280 -1680 0 0 {name=x37}
C {OR2.sym} 7460 -1450 0 0 {name=x38}
C {AND2.sym} 7260 -1490 0 0 {name=x39}
C {AND2.sym} 7260 -1400 0 0 {name=x40}
C {devices/opin.sym} 7420 -1680 0 0 {name=p30 lab=S6}
C {devices/ipin.sym} 6825 -1700 0 0 {name=p32 sig_type=std_logic lab=A2}
C {devices/ipin.sym} 6655 -1770 0 0 {name=p33 sig_type=std_logic lab=B2}
C {XOR2.sym} 7830 -1670 0 0 {name=x41}
C {XOR2.sym} 8120 -1660 0 0 {name=x42}
C {OR2.sym} 8300 -1430 0 0 {name=x43}
C {AND2.sym} 8100 -1470 0 0 {name=x44}
C {AND2.sym} 8100 -1380 0 0 {name=x45}
C {devices/opin.sym} 8260 -1660 0 0 {name=p35 lab=S7}
C {devices/ipin.sym} 7665 -1680 0 0 {name=p36 sig_type=std_logic lab=A3}
C {devices/ipin.sym} 7495 -1760 0 0 {name=p37 sig_type=std_logic lab=B3}
C {devices/lab_pin.sym} 7670 -1480 0 0 {name=p41 sig_type=std_logic lab=C3}
C {4_BIT_CLA_Carry_logic.sym} 6720 -790 0 0 {name=x46}
C {devices/lab_pin.sym} 6670 -1440 2 0 {name=p43 lab=Co6}
C {devices/lab_pin.sym} 7580 -1450 2 0 {name=p44 lab=Co7}
C {devices/lab_pin.sym} 8420 -1430 2 0 {name=p45 lab=Co8}
C {XOR2.sym} 4910 -1780 0 0 {name=x47}
C {XOR2.sym} 5860 -1780 0 0 {name=x48}
C {XOR2.sym} 6740 -1780 0 0 {name=x49}
C {XOR2.sym} 7580 -1770 0 0 {name=x50}
C {XOR2.sym} 9060 -1690 0 0 {name=x51}
C {XOR2.sym} 9350 -1680 0 0 {name=x52}
C {OR2.sym} 9530 -1450 0 0 {name=x53}
C {AND2.sym} 9330 -1490 0 0 {name=x54}
C {AND2.sym} 9330 -1400 0 0 {name=x55}
C {devices/opin.sym} 9490 -1680 0 0 {name=p18 lab=S8}
C {devices/lab_pin.sym} 9650 -1450 2 0 {name=p31 lab=Co9}
C {devices/ipin.sym} 8895 -1700 0 0 {name=p46 sig_type=std_logic lab=A0}
C {devices/ipin.sym} 8675 -1780 0 0 {name=p47 sig_type=std_logic lab=B0}
C {XOR2.sym} 9920 -1690 0 0 {name=x56}
C {XOR2.sym} 10210 -1680 0 0 {name=x57}
C {OR2.sym} 10390 -1450 0 0 {name=x58}
C {AND2.sym} 10190 -1490 0 0 {name=x59}
C {AND2.sym} 10190 -1400 0 0 {name=x60}
C {devices/opin.sym} 10350 -1680 0 0 {name=p49 lab=S9}
C {devices/ipin.sym} 9755 -1700 0 0 {name=p50 sig_type=std_logic lab=A1}
C {devices/ipin.sym} 9605 -1780 0 0 {name=p51 sig_type=std_logic lab=B1}
C {XOR2.sym} 10830 -1700 0 0 {name=x61}
C {XOR2.sym} 11120 -1690 0 0 {name=x62}
C {OR2.sym} 11300 -1460 0 0 {name=x63}
C {AND2.sym} 11100 -1500 0 0 {name=x64}
C {AND2.sym} 11100 -1410 0 0 {name=x65}
C {devices/opin.sym} 11260 -1690 0 0 {name=p53 lab=S10}
C {devices/ipin.sym} 10665 -1710 0 0 {name=p54 sig_type=std_logic lab=A2}
C {devices/ipin.sym} 10495 -1780 0 0 {name=p55 sig_type=std_logic lab=B2}
C {XOR2.sym} 11670 -1680 0 0 {name=x66}
C {XOR2.sym} 11960 -1670 0 0 {name=x67}
C {OR2.sym} 12140 -1440 0 0 {name=x68}
C {AND2.sym} 11940 -1480 0 0 {name=x69}
C {AND2.sym} 11940 -1390 0 0 {name=x70}
C {devices/opin.sym} 12100 -1670 0 0 {name=p57 lab=S11}
C {devices/ipin.sym} 11505 -1690 0 0 {name=p58 sig_type=std_logic lab=A3}
C {devices/ipin.sym} 11335 -1770 0 0 {name=p59 sig_type=std_logic lab=B3}
C {4_BIT_CLA_Carry_logic.sym} 10560 -800 0 0 {name=x71}
C {devices/lab_pin.sym} 10510 -1450 2 0 {name=p61 lab=Co10}
C {devices/lab_pin.sym} 11420 -1460 2 0 {name=p62 lab=C3}
C {devices/lab_pin.sym} 12260 -1440 2 0 {name=p63 lab=C4}
C {XOR2.sym} 8750 -1790 0 0 {name=x72}
C {XOR2.sym} 9700 -1790 0 0 {name=x73}
C {XOR2.sym} 10580 -1790 0 0 {name=x74}
C {XOR2.sym} 11420 -1780 0 0 {name=x75}
C {XOR2.sym} 12790 -1700 0 0 {name=x76}
C {XOR2.sym} 13080 -1690 0 0 {name=x77}
C {OR2.sym} 13260 -1460 0 0 {name=x78}
C {AND2.sym} 13060 -1500 0 0 {name=x79}
C {AND2.sym} 13060 -1410 0 0 {name=x80}
C {devices/opin.sym} 13220 -1690 0 0 {name=p64 lab=S12}
C {devices/lab_pin.sym} 13380 -1460 2 0 {name=p65 lab=C5}
C {devices/ipin.sym} 12625 -1710 0 0 {name=p66 sig_type=std_logic lab=A0}
C {devices/ipin.sym} 12405 -1790 0 0 {name=p67 sig_type=std_logic lab=B0}
C {XOR2.sym} 13650 -1700 0 0 {name=x81}
C {XOR2.sym} 13940 -1690 0 0 {name=x82}
C {OR2.sym} 14120 -1460 0 0 {name=x83}
C {AND2.sym} 13920 -1500 0 0 {name=x84}
C {AND2.sym} 13920 -1410 0 0 {name=x85}
C {devices/opin.sym} 14080 -1690 0 0 {name=p68 lab=S13}
C {devices/ipin.sym} 13485 -1710 0 0 {name=p69 sig_type=std_logic lab=A1}
C {devices/ipin.sym} 13335 -1790 0 0 {name=p70 sig_type=std_logic lab=B1}
C {devices/lab_pin.sym} 13490 -1510 0 0 {name=p71 sig_type=std_logic lab=C1}
C {XOR2.sym} 14560 -1710 0 0 {name=x86}
C {XOR2.sym} 14850 -1700 0 0 {name=x87}
C {OR2.sym} 15030 -1470 0 0 {name=x88}
C {AND2.sym} 14830 -1510 0 0 {name=x89}
C {AND2.sym} 14830 -1420 0 0 {name=x90}
C {devices/opin.sym} 14990 -1700 0 0 {name=p72 lab=S14}
C {devices/ipin.sym} 14395 -1720 0 0 {name=p73 sig_type=std_logic lab=A2}
C {devices/ipin.sym} 14225 -1790 0 0 {name=p74 sig_type=std_logic lab=B2}
C {XOR2.sym} 15400 -1690 0 0 {name=x91}
C {XOR2.sym} 15690 -1680 0 0 {name=x92}
C {OR2.sym} 15870 -1450 0 0 {name=x93}
C {AND2.sym} 15670 -1490 0 0 {name=x94}
C {AND2.sym} 15670 -1400 0 0 {name=x95}
C {devices/opin.sym} 15830 -1680 0 0 {name=p76 lab=S15}
C {devices/ipin.sym} 15235 -1700 0 0 {name=p77 sig_type=std_logic lab=A3}
C {devices/ipin.sym} 15065 -1780 0 0 {name=p78 sig_type=std_logic lab=B3}
C {4_BIT_CLA_Carry_logic.sym} 14290 -810 0 0 {name=x96}
C {devices/lab_pin.sym} 14240 -1460 2 0 {name=p81 lab=C6}
C {devices/lab_pin.sym} 15150 -1470 2 0 {name=p82 lab=C7}
C {XOR2.sym} 12480 -1800 0 0 {name=x97}
C {XOR2.sym} 13430 -1800 0 0 {name=x98}
C {XOR2.sym} 14310 -1800 0 0 {name=x99}
C {XOR2.sym} 15150 -1790 0 0 {name=x100}
C {XOR2.sym} 15240 470 2 0 {name=x101}
C {XOR2.sym} 14950 460 2 0 {name=x102}
C {OR2.sym} 14770 230 2 0 {name=x103}
C {AND2.sym} 14970 270 2 0 {name=x104}
C {AND2.sym} 14970 180 2 0 {name=x105}
C {devices/opin.sym} 14810 460 2 0 {name=p14 lab=S16}
C {devices/ipin.sym} 15405 480 2 0 {name=p28 sig_type=std_logic lab=A0}
C {devices/ipin.sym} 15625 560 2 0 {name=p29 sig_type=std_logic lab=B0}
C {XOR2.sym} 14380 470 2 0 {name=x106}
C {XOR2.sym} 14090 460 2 0 {name=x107}
C {OR2.sym} 13910 230 2 0 {name=x108}
C {AND2.sym} 14110 270 2 0 {name=x109}
C {AND2.sym} 14110 180 2 0 {name=x110}
C {devices/opin.sym} 13950 460 2 0 {name=p42 lab=S17}
C {devices/ipin.sym} 14545 480 2 0 {name=p48 sig_type=std_logic lab=A1}
C {devices/ipin.sym} 14695 560 2 0 {name=p52 sig_type=std_logic lab=B1}
C {XOR2.sym} 13470 480 2 0 {name=x111}
C {XOR2.sym} 13180 470 2 0 {name=x112}
C {OR2.sym} 13000 240 2 0 {name=x113}
C {AND2.sym} 13200 280 2 0 {name=x114}
C {AND2.sym} 13200 190 2 0 {name=x115}
C {devices/opin.sym} 13040 470 2 0 {name=p56 lab=S18}
C {devices/ipin.sym} 13635 490 2 0 {name=p60 sig_type=std_logic lab=A2}
C {devices/ipin.sym} 13805 560 2 0 {name=p75 sig_type=std_logic lab=B2}
C {XOR2.sym} 12630 460 2 0 {name=x116}
C {XOR2.sym} 12340 450 2 0 {name=x117}
C {OR2.sym} 12160 220 2 0 {name=x118}
C {AND2.sym} 12360 260 2 0 {name=x119}
C {AND2.sym} 12360 170 2 0 {name=x120}
C {devices/opin.sym} 12200 450 2 0 {name=p79 lab=S19}
C {devices/ipin.sym} 12795 470 2 0 {name=p83 sig_type=std_logic lab=A3}
C {devices/ipin.sym} 12965 550 2 0 {name=p84 sig_type=std_logic lab=B3}
C {4_BIT_CLA_Carry_logic.sym} 13740 -420 2 0 {name=x121}
C {XOR2.sym} 15550 570 2 0 {name=x122}
C {XOR2.sym} 14600 570 2 0 {name=x123}
C {XOR2.sym} 13720 570 2 0 {name=x124}
C {XOR2.sym} 12880 560 2 0 {name=x125}
C {XOR2.sym} 11510 480 2 0 {name=x126}
C {XOR2.sym} 11220 470 2 0 {name=x127}
C {OR2.sym} 11040 240 2 0 {name=x128}
C {AND2.sym} 11240 280 2 0 {name=x129}
C {AND2.sym} 11240 190 2 0 {name=x130}
C {devices/opin.sym} 11080 470 2 0 {name=p88 lab=S20}
C {devices/ipin.sym} 11675 490 2 0 {name=p90 sig_type=std_logic lab=A0}
C {devices/ipin.sym} 11895 570 2 0 {name=p91 sig_type=std_logic lab=B0}
C {XOR2.sym} 10650 480 2 0 {name=x131}
C {XOR2.sym} 10360 470 2 0 {name=x132}
C {OR2.sym} 10180 240 2 0 {name=x133}
C {AND2.sym} 10380 280 2 0 {name=x134}
C {AND2.sym} 10380 190 2 0 {name=x135}
C {devices/opin.sym} 10220 470 2 0 {name=p92 lab=S21}
C {devices/ipin.sym} 10815 490 2 0 {name=p93 sig_type=std_logic lab=A1}
C {devices/ipin.sym} 10965 570 2 0 {name=p94 sig_type=std_logic lab=B1}
C {XOR2.sym} 9740 490 2 0 {name=x136}
C {XOR2.sym} 9450 480 2 0 {name=x137}
C {OR2.sym} 9270 250 2 0 {name=x138}
C {AND2.sym} 9470 290 2 0 {name=x139}
C {AND2.sym} 9470 200 2 0 {name=x140}
C {devices/opin.sym} 9310 480 2 0 {name=p95 lab=S22}
C {devices/ipin.sym} 9905 500 2 0 {name=p96 sig_type=std_logic lab=A2}
C {devices/ipin.sym} 10075 570 2 0 {name=p97 sig_type=std_logic lab=B2}
C {XOR2.sym} 8900 470 2 0 {name=x141}
C {XOR2.sym} 8610 460 2 0 {name=x142}
C {OR2.sym} 8430 230 2 0 {name=x143}
C {AND2.sym} 8630 270 2 0 {name=x144}
C {AND2.sym} 8630 180 2 0 {name=x145}
C {devices/opin.sym} 8470 460 2 0 {name=p98 lab=S23}
C {devices/ipin.sym} 9065 480 2 0 {name=p99 sig_type=std_logic lab=A3}
C {devices/ipin.sym} 9235 560 2 0 {name=p100 sig_type=std_logic lab=B3}
C {devices/lab_pin.sym} 9060 280 2 0 {name=p101 sig_type=std_logic lab=C3}
C {4_BIT_CLA_Carry_logic.sym} 10010 -410 2 0 {name=x146}
C {XOR2.sym} 11820 580 2 0 {name=x147}
C {XOR2.sym} 10870 580 2 0 {name=x148}
C {XOR2.sym} 9990 580 2 0 {name=x149}
C {XOR2.sym} 9150 570 2 0 {name=x150}
C {XOR2.sym} 7670 490 2 0 {name=x151}
C {XOR2.sym} 7380 480 2 0 {name=x152}
C {OR2.sym} 7200 250 2 0 {name=x153}
C {AND2.sym} 7400 290 2 0 {name=x154}
C {AND2.sym} 7400 200 2 0 {name=x155}
C {devices/opin.sym} 7240 480 2 0 {name=p105 lab=S24}
C {devices/ipin.sym} 7835 500 2 0 {name=p107 sig_type=std_logic lab=A0}
C {devices/ipin.sym} 8055 580 2 0 {name=p108 sig_type=std_logic lab=B0}
C {XOR2.sym} 6810 490 2 0 {name=x156}
C {XOR2.sym} 6520 480 2 0 {name=x157}
C {OR2.sym} 6340 250 2 0 {name=x158}
C {AND2.sym} 6540 290 2 0 {name=x159}
C {AND2.sym} 6540 200 2 0 {name=x160}
C {devices/opin.sym} 6380 480 2 0 {name=p109 lab=S25}
C {devices/ipin.sym} 6975 500 2 0 {name=p110 sig_type=std_logic lab=A1}
C {devices/ipin.sym} 7125 580 2 0 {name=p111 sig_type=std_logic lab=B1}
C {XOR2.sym} 5900 500 2 0 {name=x161}
C {XOR2.sym} 5610 490 2 0 {name=x162}
C {OR2.sym} 5430 260 2 0 {name=x163}
C {AND2.sym} 5630 300 2 0 {name=x164}
C {AND2.sym} 5630 210 2 0 {name=x165}
C {devices/opin.sym} 5470 490 2 0 {name=p112 lab=S26}
C {devices/ipin.sym} 6065 510 2 0 {name=p113 sig_type=std_logic lab=A2}
C {devices/ipin.sym} 6235 580 2 0 {name=p114 sig_type=std_logic lab=B2}
C {XOR2.sym} 5060 480 2 0 {name=x166}
C {XOR2.sym} 4770 470 2 0 {name=x167}
C {OR2.sym} 4590 240 2 0 {name=x168}
C {AND2.sym} 4790 280 2 0 {name=x169}
C {AND2.sym} 4790 190 2 0 {name=x170}
C {devices/opin.sym} 4630 470 2 0 {name=p115 lab=S27}
C {devices/ipin.sym} 5225 490 2 0 {name=p116 sig_type=std_logic lab=A3}
C {devices/ipin.sym} 5395 570 2 0 {name=p117 sig_type=std_logic lab=B3}
C {4_BIT_CLA_Carry_logic.sym} 6170 -400 2 0 {name=x171}
C {XOR2.sym} 7980 590 2 0 {name=x172}
C {XOR2.sym} 7030 590 2 0 {name=x173}
C {XOR2.sym} 6150 590 2 0 {name=x174}
C {XOR2.sym} 5310 580 2 0 {name=x175}
C {XOR2.sym} 3940 500 2 0 {name=x176}
C {XOR2.sym} 3650 490 2 0 {name=x177}
C {OR2.sym} 3470 260 2 0 {name=x178}
C {AND2.sym} 3670 300 2 0 {name=x179}
C {AND2.sym} 3670 210 2 0 {name=x180}
C {devices/opin.sym} 3510 490 2 0 {name=p121 lab=S28}
C {devices/ipin.sym} 4105 510 2 0 {name=p123 sig_type=std_logic lab=A0}
C {devices/ipin.sym} 4325 590 2 0 {name=p124 sig_type=std_logic lab=B0}
C {XOR2.sym} 3080 500 2 0 {name=x181}
C {XOR2.sym} 2790 490 2 0 {name=x182}
C {OR2.sym} 2610 260 2 0 {name=x183}
C {AND2.sym} 2810 300 2 0 {name=x184}
C {AND2.sym} 2810 210 2 0 {name=x185}
C {devices/opin.sym} 2650 490 2 0 {name=p125 lab=S29}
C {devices/ipin.sym} 3245 510 2 0 {name=p126 sig_type=std_logic lab=A1}
C {devices/ipin.sym} 3395 590 2 0 {name=p127 sig_type=std_logic lab=B1}
C {XOR2.sym} 2170 510 2 0 {name=x186}
C {XOR2.sym} 1880 500 2 0 {name=x187}
C {OR2.sym} 1700 270 2 0 {name=x188}
C {AND2.sym} 1900 310 2 0 {name=x189}
C {AND2.sym} 1900 220 2 0 {name=x190}
C {devices/opin.sym} 1740 500 2 0 {name=p129 lab=S30}
C {devices/ipin.sym} 2335 520 2 0 {name=p130 sig_type=std_logic lab=A2}
C {devices/ipin.sym} 2505 590 2 0 {name=p131 sig_type=std_logic lab=B2}
C {XOR2.sym} 1330 490 2 0 {name=x191}
C {XOR2.sym} 1040 480 2 0 {name=x192}
C {OR2.sym} 860 250 2 0 {name=x193}
C {AND2.sym} 1060 290 2 0 {name=x194}
C {AND2.sym} 1060 200 2 0 {name=x195}
C {devices/opin.sym} 900 480 2 0 {name=p132 lab=S31}
C {devices/ipin.sym} 1495 500 2 0 {name=p133 sig_type=std_logic lab=A3}
C {devices/ipin.sym} 1665 580 2 0 {name=p134 sig_type=std_logic lab=B3}
C {4_BIT_CLA_Carry_logic.sym} 2440 -390 2 0 {name=x196}
C {devices/opin.sym} 2230 -400 2 0 {name=p135 lab=Cout}
C {XOR2.sym} 4250 600 2 0 {name=x197}
C {XOR2.sym} 3300 600 2 0 {name=x198}
C {XOR2.sym} 2420 600 2 0 {name=x199}
C {XOR2.sym} 1580 590 2 0 {name=x200}
