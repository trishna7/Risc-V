v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
B 2 8650 -7440 9450 -7040 {flags=graph
y1=0
y2=2
ypos1=-0.1
ypos2=1.9
divy=5
subdivy=1
unity=1
x1=8.2718061e-25
x2=1e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
digital=1

color="10 10 10 10 4 4"
node="sel;s0,s1
s
a;a[31],a[30],a[29],a[28],a[27],a[26],a[25],a[24],a[23],a[22],a[21],a[20],a[19],a[18],a[17],a[16],a[15],a[14],a[13],a[12],a[11],a[10],a[9],a[8],a[7],a[6],a[5],a[4],a[3],a[2],a[1],a[0]
o;o[31],o[30],o[29],o[28],o[27],o[26],o[25],o[24],o[23],o[22],o[21],o[20],o[19],o[18],o[17],o[16],o[15],o[14],o[13],o[12],o[11],o[10],o[9],o[8],o[7],o[6],o[5],o[4],o[3],o[2],o[1],o[0]
ssel;s0,s1
stg1;n[31],n[30],n[29],n[28],n[27],n[26],n[25],n[24],n[23],n[22],n[21],n[20],n[19],n[18],n[17],n[16],n[15],n[14],n[13],n[12],n[11],n[10],n[9],n[8],n[7],n[6],n[5],n[4],n[3],n[2],n[1],n[0]"
rainbow=1}
B 2 8650 -7020 9450 -6620 {flags=graph
y1=0
y2=2
ypos1=15.4
ypos2=17.4
divy=5
subdivy=1
unity=1
x1=8.2718061e-25
x2=1e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
digital=1

color="11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 17 18 19 20 21 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 7 8 9"
node="o[31]
o[30]
o[29]
o[28]
o[27]
o[26]
o[25]
o[24]
o[23]
o[22]
o[21]
o[20]
o[19]
o[18]
o[17]
o[16]
o[15]
o[14]
o[13]
o[12]
o[11]
o[10]
o[9]
o[8]
o[7]
o[6]
o[5]
o[4]
o[3]
o[2]
o[1]
o[0]
s
l
net1
net2
net3
net4
net5
net6
net7
net8
net9
net10
net11
net12
net13
net14
net15
net16
net17
net18
net19
net20
net21
net22
net23
net24
net25
net64
net65
net66
net67
net75
net76
net77
net78
net79
net80
net81
net82
net83
net84
net85
net86
net87
net88
net89
net90
net91
net92
net93
net94
net95
net96
"
rainbow=1}
B 2 8650 -7870 9450 -7470 {flags=graph
y1=0
y2=2
ypos1=-0.3109453
ypos2=1.6890551
divy=5
subdivy=1
unity=1
x1=8.2718061e-25
x2=1e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
digital=1

color="11 11 11 11"
node="s0
s1
s2
net6"
rainbow=1}
T {number bit shift by mux
s0 0 0 1 1
s1 0 1 0 1
O  0 1 2 3 bit shift
} 610 -9000 0 0 1 1 {}
T {Shift type
S 0 1
O L R} 1570 -9000 0 0 1 1 {}
N 3030 -7100 3090 -7100 {
lab=n[4]}
N 3030 -6950 3090 -6950 {
lab=n[5]}
N 3030 -6650 3090 -6650 {
lab=n[7]}
N 3030 -5900 3090 -5900 {
lab=n[12]}
N 3030 -5750 3090 -5750 {
lab=n[13]}
N 3030 -5600 3090 -5600 {
lab=n[14]}
N 3030 -5440 3090 -5440 {
lab=n[15]}
N 3030 -5290 3090 -5290 {
lab=n[16]}
N 3030 -5140 3090 -5140 {
lab=n[17]}
N 3030 -4990 3090 -4990 {
lab=n[18]}
N 3030 -4840 3090 -4840 {
lab=n[19]}
N 3030 -4690 3090 -4690 {
lab=n[20]}
N 3030 -4390 3090 -4390 {
lab=n[22]}
N 3030 -4240 3090 -4240 {
lab=n[23]}
N 3030 -4090 3090 -4090 {
lab=n[24]}
N 3030 -3940 3090 -3940 {
lab=n[25]}
N 3030 -3790 3090 -3790 {
lab=n[26]}
N 3030 -3190 3090 -3190 {
lab=n[30]}
N 3030 -3040 3090 -3040 {
lab=n[31]}
N 3090 -7100 3150 -7100 {
lab=n[4]}
N 3090 -6950 3150 -6950 {
lab=n[5]}
N 3090 -5140 3150 -5140 {
lab=n[17]}
N 3090 -4990 3150 -4990 {
lab=n[18]}
N 3090 -4390 3150 -4390 {
lab=n[22]}
N 3090 -4240 3150 -4240 {
lab=n[23]}
N 3090 -4090 3150 -4090 {
lab=n[24]}
N 3090 -3940 3150 -3940 {
lab=n[25]}
N 3090 -3190 3150 -3190 {
lab=n[30]}
N 3090 -3040 3150 -3040 {
lab=n[31]}
N 3570 -7700 3980 -7700 {
lab=n[0]}
N 3570 -7550 3980 -7550 {
lab=n[1]}
N 3570 -7400 3980 -7400 {
lab=n[2]}
N 3570 -7250 3980 -7250 {
lab=n[3]}
N 3570 -7100 3980 -7100 {
lab=n[4]}
N 3570 -6950 3980 -6950 {
lab=n[5]}
N 3570 -6650 3980 -6650 {
lab=n[7]}
N 3570 -6500 3980 -6500 {
lab=n[8]}
N 3570 -6350 3980 -6350 {
lab=n[9]}
N 3570 -6200 3980 -6200 {
lab=n[10]}
N 3570 -6050 3980 -6050 {
lab=n[11]}
N 3570 -5900 3980 -5900 {
lab=n[12]}
N 3570 -5750 3980 -5750 {
lab=n[13]}
N 3570 -5600 3980 -5600 {
lab=n[14]}
N 3570 -5440 3980 -5440 {
lab=n[15]}
N 3570 -5290 3980 -5290 {
lab=n[16]}
N 3570 -5140 3980 -5140 {
lab=n[17]}
N 3570 -4990 3980 -4990 {
lab=n[18]}
N 3570 -4840 3980 -4840 {
lab=n[19]}
N 3570 -4690 3980 -4690 {
lab=n[20]}
N 3570 -4540 3980 -4540 {
lab=n[21]}
N 3570 -4390 3980 -4390 {
lab=n[22]}
N 3570 -4240 3980 -4240 {
lab=n[23]}
N 3570 -4090 3980 -4090 {
lab=n[24]}
N 3570 -3940 3980 -3940 {
lab=n[25]}
N 3570 -3790 3980 -3790 {
lab=n[26]}
N 3570 -3640 3980 -3640 {
lab=n[27]}
N 3570 -3490 3980 -3490 {
lab=n[28]}
N 3570 -3340 3980 -3340 {
lab=n[29]}
N 3570 -3190 3980 -3190 {
lab=n[30]}
N 3570 -3040 3980 -3040 {
lab=n[31]}
N 4090 -4040 4200 -4040 {
lab=O[24]}
N 4090 -3890 4200 -3890 {
lab=O[25]}
N 4090 -3740 4200 -3740 {
lab=O[26]}
N 4090 -3590 4200 -3590 {
lab=O[27]}
N 4090 -3440 4200 -3440 {
lab=O[28]}
N 4090 -3290 4200 -3290 {
lab=O[29]}
N 4090 -3140 4200 -3140 {
lab=O[30]}
N 4090 -2990 4200 -2990 {
lab=O[31]}
N 4090 -5240 4200 -5240 {
lab=O[16]}
N 4090 -5090 4200 -5090 {
lab=O[17]}
N 4090 -4940 4200 -4940 {
lab=O[18]}
N 4090 -4790 4200 -4790 {
lab=O[19]}
N 4090 -4640 4200 -4640 {
lab=O[20]}
N 4090 -4490 4200 -4490 {
lab=O[21]}
N 4090 -4340 4200 -4340 {
lab=O[22]}
N 4090 -4190 4200 -4190 {
lab=O[23]}
N 4090 -6450 4200 -6450 {
lab=O[8]}
N 4090 -6300 4200 -6300 {
lab=O[9]}
N 4090 -6150 4200 -6150 {
lab=O[10]}
N 4090 -6000 4200 -6000 {
lab=O[11]}
N 4090 -5850 4200 -5850 {
lab=O[12]}
N 4090 -5700 4200 -5700 {
lab=O[13]}
N 4090 -5550 4200 -5550 {
lab=O[14]}
N 4090 -7650 4200 -7650 {
lab=O[0]}
N 4090 -7500 4200 -7500 {
lab=O[1]}
N 4090 -7350 4200 -7350 {
lab=O[2]}
N 4090 -7200 4200 -7200 {
lab=O[3]}
N 4090 -7050 4200 -7050 {
lab=O[4]}
N 4090 -6900 4200 -6900 {
lab=O[5]}
N 4090 -6750 4200 -6750 {
lab=O[6]}
N 4090 -6600 4200 -6600 {
lab=O[7]}
N 3280 -6820 3290 -6820 {
lab=n[9]}
N 3420 -7650 3420 -7620 {
lab=O[0]}
N 3420 -7500 3420 -7480 {
lab=O[1]}
N 3420 -7350 3420 -7330 {
lab=O[2]}
N 3420 -2990 3420 -2970 {
lab=O[31]}
N 3420 -3140 3420 -3110 {
lab=O[30]}
N 3420 -3290 3420 -3260 {
lab=O[29]}
N 3420 -3440 3420 -3410 {
lab=O[28]}
N 3420 -3590 3420 -3570 {
lab=O[27]}
N 3420 -3740 3420 -3710 {
lab=O[26]}
N 3420 -3890 3420 -3850 {
lab=O[25]}
N 3420 -4040 3420 -4010 {
lab=O[24]}
N 3420 -4190 3420 -4160 {
lab=O[23]}
N 3420 -4340 3420 -4310 {
lab=O[22]}
N 3420 -4490 3420 -4460 {
lab=O[21]}
N 3420 -4640 3420 -4610 {
lab=O[20]}
N 3420 -4790 3420 -4760 {
lab=O[19]}
N 3420 -4940 3420 -4910 {
lab=O[18]}
N 3420 -5090 3420 -5060 {
lab=O[17]}
N 3420 -5240 3420 -5210 {
lab=O[16]}
N 3420 -5390 3420 -5360 {
lab=O[15]}
N 3420 -5550 3420 -5520 {
lab=O[14]}
N 3420 -5700 3420 -5680 {
lab=O[13]}
N 3420 -5850 3420 -5830 {
lab=O[12]}
N 3420 -6000 3420 -5970 {
lab=O[11]}
N 3420 -6150 3420 -6130 {
lab=O[10]}
N 3420 -6300 3420 -6270 {
lab=O[9]}
N 3420 -6450 3420 -6420 {
lab=O[8]}
N 3420 -6600 3420 -6570 {
lab=O[7]}
N 3420 -6750 3420 -6720 {
lab=O[6]}
N 3420 -6900 3420 -6870 {
lab=O[5]}
N 3420 -7050 3420 -7040 {
lab=O[4]}
N 3420 -7200 3420 -7180 {
lab=O[3]}
N 3250 -5280 3250 -2970 {
lab=S}
N 3250 -7580 3250 -5270 {
lab=S}
N 3250 -7710 3250 -7580 {
lab=S}
N 3270 -7590 3290 -7590 {
lab=l}
N 3250 -7620 3290 -7620 {
lab=S}
N 3250 -7480 3290 -7480 {
lab=S}
N 3250 -7330 3290 -7330 {
lab=S}
N 3250 -7180 3290 -7180 {
lab=S}
N 3250 -7040 3290 -7040 {
lab=S}
N 3250 -6870 3290 -6870 {
lab=S}
N 3250 -6720 3290 -6720 {
lab=S}
N 3250 -6570 3290 -6570 {
lab=S}
N 3250 -6420 3290 -6420 {
lab=S}
N 3250 -6270 3290 -6270 {
lab=S}
N 3250 -6130 3290 -6130 {
lab=S}
N 3250 -5970 3290 -5970 {
lab=S}
N 3250 -5830 3290 -5830 {
lab=S}
N 3250 -5680 3290 -5680 {
lab=S}
N 3250 -5520 3290 -5520 {
lab=S}
N 3250 -5360 3290 -5360 {
lab=S}
N 3250 -5210 3290 -5210 {
lab=S}
N 3250 -5060 3290 -5060 {
lab=S}
N 3250 -4910 3290 -4910 {
lab=S}
N 3250 -4760 3290 -4760 {
lab=S}
N 3250 -4610 3290 -4610 {
lab=S}
N 3250 -4460 3290 -4460 {
lab=S}
N 3250 -4310 3290 -4310 {
lab=S}
N 3250 -4160 3290 -4160 {
lab=S}
N 3250 -4010 3290 -4010 {
lab=S}
N 3250 -3850 3290 -3850 {
lab=S}
N 3250 -3710 3290 -3710 {
lab=S}
N 3250 -3570 3290 -3570 {
lab=S}
N 3250 -3410 3290 -3410 {
lab=S}
N 3250 -3260 3290 -3260 {
lab=S}
N 3250 -3110 3290 -3110 {
lab=S}
N 3250 -2970 3290 -2970 {
lab=S}
N 3250 -7760 3250 -7710 {
lab=S}
N 3150 -7100 3570 -7100 {
lab=n[4]}
N 3150 -6950 3570 -6950 {
lab=n[5]}
N 3150 -6050 3570 -6050 {
lab=n[11]}
N 3150 -5140 3570 -5140 {
lab=n[17]}
N 3150 -4990 3570 -4990 {
lab=n[18]}
N 3150 -4390 3570 -4390 {
lab=n[22]}
N 3150 -4240 3570 -4240 {
lab=n[23]}
N 3150 -4090 3570 -4090 {
lab=n[24]}
N 3150 -3940 3570 -3940 {
lab=n[25]}
N 3150 -3340 3570 -3340 {
lab=n[29]}
N 3150 -3190 3570 -3190 {
lab=n[30]}
N 3150 -3040 3570 -3040 {
lab=n[31]}
N 3070 -7010 3290 -7010 {
lab=#net1}
N 3080 -6840 3290 -6840 {
lab=#net2}
N 3090 -6690 3300 -6690 {
lab=#net3}
N 3030 -6800 3980 -6800 {
lab=n[6]}
N 3090 -5900 3570 -5900 {
lab=n[12]}
N 3230 -4580 3290 -4580 {
lab=n[16]}
N 3200 -4130 3290 -4130 {
lab=n[19]}
N 3190 -3980 3290 -3980 {
lab=n[20]}
N 3170 -3680 3290 -3680 {
lab=n[22]}
N 3160 -3540 3290 -3540 {
lab=n[23]}
N 3150 -3380 3290 -3380 {
lab=n[24]}
N 3130 -3080 3290 -3080 {
lab=n[26]}
N 3120 -2940 3290 -2940 {
lab=n[27]}
N 3420 -7650 4090 -7650 {
lab=O[0]}
N 3420 -7500 4090 -7500 {
lab=O[1]}
N 3420 -7350 4090 -7350 {
lab=O[2]}
N 3420 -7200 4090 -7200 {
lab=O[3]}
N 3420 -7050 4090 -7050 {
lab=O[4]}
N 3420 -6900 4090 -6900 {
lab=O[5]}
N 3420 -6750 4090 -6750 {
lab=O[6]}
N 3420 -6600 4090 -6600 {
lab=O[7]}
N 3420 -6450 4090 -6450 {
lab=O[8]}
N 3420 -6300 4090 -6300 {
lab=O[9]}
N 3420 -6150 4090 -6150 {
lab=O[10]}
N 3420 -6000 4090 -6000 {
lab=O[11]}
N 3420 -5850 4090 -5850 {
lab=O[12]}
N 3420 -5700 4090 -5700 {
lab=O[13]}
N 3420 -5550 4090 -5550 {
lab=O[14]}
N 3420 -5240 4090 -5240 {
lab=O[16]}
N 3420 -5090 4090 -5090 {
lab=O[17]}
N 3420 -4940 4090 -4940 {
lab=O[18]}
N 3420 -4790 4090 -4790 {
lab=O[19]}
N 3420 -4640 4090 -4640 {
lab=O[20]}
N 3420 -4490 4090 -4490 {
lab=O[21]}
N 3420 -4340 4090 -4340 {
lab=O[22]}
N 3420 -5400 4090 -5400 {
lab=O[15]}
N 3420 -5400 3420 -5390 {
lab=O[15]}
N 3420 -4190 4090 -4190 {
lab=O[23]}
N 3420 -4040 4090 -4040 {
lab=O[24]}
N 3420 -3890 4090 -3890 {
lab=O[25]}
N 3420 -3740 4090 -3740 {
lab=O[26]}
N 3420 -3590 4090 -3590 {
lab=O[27]}
N 3420 -3440 4090 -3440 {
lab=O[28]}
N 3420 -3290 4090 -3290 {
lab=O[29]}
N 3420 -3140 4090 -3140 {
lab=O[30]}
N 3420 -2990 4090 -2990 {
lab=O[31]}
N 3210 -2920 3290 -2920 {
lab=l}
N 3210 -2920 3210 -2720 {
lab=l}
N 3240 -3060 3290 -3060 {
lab=l}
N 3240 -3210 3290 -3210 {
lab=l}
N 3240 -3360 3290 -3360 {
lab=l}
N 3240 -3520 3290 -3520 {
lab=n[31]}
N 3240 -3660 3290 -3660 {
lab=n[30]}
N 3240 -3800 3290 -3800 {
lab=n[29]}
N 3240 -4110 3290 -4110 {
lab=n[27]}
N 3240 -4410 3290 -4410 {
lab=n[25]}
N 3240 -4560 3290 -4560 {
lab=n[24]}
N 3240 -4710 3290 -4710 {
lab=n[23]}
N 3240 -4860 3290 -4860 {
lab=n[22]}
N 3240 -5010 3290 -5010 {
lab=n[21]}
N 3240 -5160 3290 -5160 {
lab=n[20]}
N 3240 -5310 3290 -5310 {
lab=n[19]}
N 3240 -5470 3290 -5470 {
lab=n[18]}
N 3240 -5630 3290 -5630 {
lab=n[17]}
N 3240 -5780 3290 -5780 {
lab=n[16]}
N 3240 -5920 3290 -5920 {
lab=n[15]}
N 3240 -6080 3290 -6080 {
lab=n[14]}
N 3240 -6220 3290 -6220 {
lab=n[13]}
N 3240 -6370 3290 -6370 {
lab=n[12]}
N 3240 -6520 3290 -6520 {
lab=n[11]}
N 3240 -6670 3290 -6670 {
lab=n[10]}
N 3240 -6820 3280 -6820 {
lab=n[9]}
N 3230 -7130 3290 -7130 {
lab=n[7]}
N 3240 -7430 3290 -7430 {
lab=n[5]}
N 3230 -7570 3290 -7570 {
lab=n[4]}
N 3270 -7770 3270 -7590 {
lab=l}
N 4090 -5400 4200 -5400 {
lab=O[15]}
N 4200 -4040 4310 -4040 {
lab=O[24]}
N 4200 -3890 4310 -3890 {
lab=O[25]}
N 4200 -3740 4310 -3740 {
lab=O[26]}
N 4200 -3590 4310 -3590 {
lab=O[27]}
N 4200 -3440 4310 -3440 {
lab=O[28]}
N 4200 -3290 4310 -3290 {
lab=O[29]}
N 4200 -3140 4310 -3140 {
lab=O[30]}
N 4200 -2990 4310 -2990 {
lab=O[31]}
N 4200 -5240 4310 -5240 {
lab=O[16]}
N 4200 -5090 4310 -5090 {
lab=O[17]}
N 4200 -4940 4310 -4940 {
lab=O[18]}
N 4200 -4790 4310 -4790 {
lab=O[19]}
N 4200 -4640 4310 -4640 {
lab=O[20]}
N 4200 -4490 4310 -4490 {
lab=O[21]}
N 4200 -4340 4310 -4340 {
lab=O[22]}
N 4200 -4190 4310 -4190 {
lab=O[23]}
N 4200 -6450 4310 -6450 {
lab=O[8]}
N 4200 -6300 4310 -6300 {
lab=O[9]}
N 4200 -6150 4310 -6150 {
lab=O[10]}
N 4200 -6000 4310 -6000 {
lab=O[11]}
N 4200 -5850 4310 -5850 {
lab=O[12]}
N 4200 -5700 4310 -5700 {
lab=O[13]}
N 4200 -5550 4310 -5550 {
lab=O[14]}
N 4200 -7650 4310 -7650 {
lab=O[0]}
N 4200 -7500 4310 -7500 {
lab=O[1]}
N 4200 -7350 4310 -7350 {
lab=O[2]}
N 4200 -7200 4310 -7200 {
lab=O[3]}
N 4200 -7050 4310 -7050 {
lab=O[4]}
N 4200 -6900 4310 -6900 {
lab=O[5]}
N 4200 -6750 4310 -6750 {
lab=O[6]}
N 4200 -6600 4310 -6600 {
lab=O[7]}
N 4310 -7650 4370 -7650 {
lab=O[0]}
N 4310 -7500 4370 -7500 {
lab=O[1]}
N 4310 -7350 4370 -7350 {
lab=O[2]}
N 4310 -7200 4370 -7200 {
lab=O[3]}
N 4310 -7050 4370 -7050 {
lab=O[4]}
N 4310 -6900 4370 -6900 {
lab=O[5]}
N 4310 -6750 4370 -6750 {
lab=O[6]}
N 4310 -6600 4370 -6600 {
lab=O[7]}
N 4310 -6450 4370 -6450 {
lab=O[8]}
N 4310 -6300 4370 -6300 {
lab=O[9]}
N 4310 -6150 4370 -6150 {
lab=O[10]}
N 4310 -6000 4370 -6000 {
lab=O[11]}
N 4310 -5850 4370 -5850 {
lab=O[12]}
N 4310 -5700 4370 -5700 {
lab=O[13]}
N 4310 -5550 4370 -5550 {
lab=O[14]}
N 4310 -5390 4370 -5390 {
lab=O[15]}
N 4310 -5240 4370 -5240 {
lab=O[16]}
N 4310 -5090 4370 -5090 {
lab=O[17]}
N 4310 -4940 4370 -4940 {
lab=O[18]}
N 4310 -4790 4370 -4790 {
lab=O[19]}
N 4310 -4640 4370 -4640 {
lab=O[20]}
N 4310 -4490 4370 -4490 {
lab=O[21]}
N 4310 -4340 4370 -4340 {
lab=O[22]}
N 4310 -4190 4370 -4190 {
lab=O[23]}
N 4310 -4040 4370 -4040 {
lab=O[24]}
N 4310 -3890 4370 -3890 {
lab=O[25]}
N 4310 -3740 4370 -3740 {
lab=O[26]}
N 4310 -3590 4370 -3590 {
lab=O[27]}
N 4310 -3440 4370 -3440 {
lab=O[28]}
N 4310 -3290 4370 -3290 {
lab=O[29]}
N 4310 -3140 4370 -3140 {
lab=O[30]}
N 4310 -2990 4370 -2990 {
lab=O[31]}
N 4380 -7680 4380 -2920 {
lab=O[31:0]
bus=true}
N 4200 -5400 4310 -5400 {
lab=O[15]}
N 4310 -5400 4310 -5390 {
lab=O[15]}
N 3220 -7450 3290 -7450 {
lab=l}
N 3220 -7760 3220 -7450 {
lab=l}
N 3210 -7150 3290 -7150 {
lab=l}
N 3200 -7760 3200 -7150 {
lab=l}
N 3200 -7150 3210 -7150 {
lab=l}
N 3210 -7300 3290 -7300 {
lab=l}
N 3210 -7760 3210 -7300 {
lab=l}
N 3090 -3790 3570 -3790 {
lab=n[26]}
N 3240 -3060 3240 -2720 {
lab=l}
N 3230 -3210 3240 -3210 {
lab=l}
N 3230 -3210 3230 -2720 {
lab=l}
N 3220 -3360 3240 -3360 {
lab=l}
N 3220 -3360 3220 -2720 {
lab=l}
N 3090 -7570 3230 -7570 {
lab=n[4]}
N 3120 -7130 3230 -7130 {
lab=n[7]}
N 3140 -6820 3240 -6820 {
lab=n[9]}
N 3150 -6670 3240 -6670 {
lab=n[10]}
N 3160 -6520 3240 -6520 {
lab=n[11]}
N 3030 -6500 3580 -6500 {
lab=n[8]}
N 3170 -6370 3240 -6370 {
lab=n[12]}
N 3180 -6220 3240 -6220 {
lab=n[13]}
N 3190 -6080 3240 -6080 {
lab=n[14]}
N 3200 -5920 3240 -5920 {
lab=n[15]}
N 3210 -5780 3240 -5780 {
lab=n[16]}
N 3220 -5630 3240 -5630 {
lab=n[17]}
N 3230 -5470 3240 -5470 {
lab=n[18]}
N 3210 -5310 3240 -5310 {
lab=n[19]}
N 3200 -5160 3240 -5160 {
lab=n[20]}
N 3160 -5010 3240 -5010 {
lab=n[21]}
N 3150 -4860 3240 -4860 {
lab=n[22]}
N 3140 -4710 3240 -4710 {
lab=n[23]}
N 3090 -4690 3570 -4690 {
lab=n[20]}
N 3130 -4560 3240 -4560 {
lab=n[24]}
N 3120 -4410 3240 -4410 {
lab=n[25]}
N 3110 -4110 3240 -4110 {
lab=n[27]}
N 3090 -6650 3570 -6650 {
lab=n[7]}
N 3160 -5030 3290 -5030 {
lab=n[13]}
N 3100 -3800 3240 -3800 {
lab=n[29]}
N 3090 -3660 3240 -3660 {
lab=n[30]}
N 3080 -3520 3240 -3520 {
lab=n[31]}
N 3030 -3640 3570 -3640 {
lab=n[27]}
N 3030 -3490 3570 -3490 {
lab=n[28]}
N 3090 -4840 3570 -4840 {
lab=n[19]}
N 3090 -5290 3580 -5290 {
lab=n[16]}
N 3090 -5440 3570 -5440 {
lab=n[15]}
N 3090 -5600 3570 -5600 {
lab=n[14]}
N 3030 -6200 3570 -6200 {
lab=n[10]}
N 3030 -6350 3570 -6350 {
lab=n[9]}
N 3070 -7700 3070 -7010 {
lab=#net1}
N 3080 -7550 3080 -6840 {
lab=#net2}
N 3060 -7400 3060 -6690 {
lab=#net3}
N 3050 -7250 3050 -6540 {
lab=#net4}
N 3100 -7100 3100 -6390 {
lab=n[4]}
N 3070 -6950 3070 -6240 {
lab=n[5]}
N 3060 -6690 3090 -6690 {
lab=#net3}
N 3080 -6800 3080 -6100 {
lab=n[6]}
N 3090 -6650 3090 -5940 {
lab=n[7]}
N 3090 -5940 3100 -5940 {
lab=n[7]}
N 3030 -6050 3150 -6050 {
lab=n[11]}
N 3050 -6540 3290 -6540 {
lab=#net4}
N 3110 -6500 3110 -5800 {
lab=n[8]}
N 3100 -6390 3290 -6390 {
lab=n[4]}
N 3120 -6350 3120 -5650 {
lab=n[9]}
N 3070 -6240 3290 -6240 {
lab=n[5]}
N 3130 -6200 3130 -5490 {
lab=n[10]}
N 3080 -6100 3290 -6100 {
lab=n[6]}
N 3140 -6050 3140 -5330 {
lab=n[11]}
N 3100 -5940 3290 -5940 {
lab=n[7]}
N 3150 -5900 3150 -5180 {
lab=n[12]}
N 3110 -5800 3290 -5800 {
lab=n[8]}
N 3120 -5650 3290 -5650 {
lab=n[9]}
N 3130 -5490 3290 -5490 {
lab=n[10]}
N 3090 -5750 3570 -5750 {
lab=n[13]}
N 3160 -5750 3160 -5030 {
lab=n[13]}
N 3140 -5330 3290 -5330 {
lab=n[11]}
N 3170 -5600 3170 -4880 {
lab=n[14]}
N 3180 -5440 3180 -4730 {
lab=n[15]}
N 3190 -5290 3190 -4580 {
lab=n[16]}
N 3190 -4580 3230 -4580 {
lab=n[16]}
N 3150 -5180 3290 -5180 {
lab=n[12]}
N 3130 -5140 3130 -5030 {
lab=n[17]}
N 3110 -5030 3130 -5030 {
lab=n[17]}
N 3110 -5030 3110 -4440 {
lab=n[17]}
N 3110 -4440 3110 -4430 {
lab=n[17]}
N 3100 -4990 3100 -4280 {
lab=n[18]}
N 3220 -4840 3220 -4130 {
lab=n[19]}
N 3210 -4690 3210 -3980 {
lab=n[20]}
N 3110 -4430 3290 -4430 {
lab=n[17]}
N 3100 -4280 3290 -4280 {
lab=n[18]}
N 3170 -4540 3170 -3820 {
lab=n[21]}
N 3160 -4390 3160 -3680 {
lab=n[22]}
N 3160 -3680 3180 -3680 {
lab=n[22]}
N 3080 -3540 3160 -3540 {
lab=n[23]}
N 3080 -4240 3080 -3540 {
lab=n[23]}
N 3070 -4090 3070 -3380 {
lab=n[24]}
N 3070 -3380 3150 -3380 {
lab=n[24]}
N 3060 -3940 3060 -3220 {
lab=n[25]}
N 3140 -3790 3140 -3080 {
lab=n[26]}
N 3060 -3230 3290 -3230 {
lab=n[25]}
N 3120 -3640 3120 -2940 {
lab=n[27]}
N 3080 -3520 3080 -3050 {
lab=n[31]}
N 3090 -3660 3090 -3190 {
lab=n[30]}
N 3080 -3050 3080 -3040 {
lab=n[31]}
N 3030 -3340 3150 -3340 {
lab=n[29]}
N 3100 -3800 3100 -3340 {
lab=n[29]}
N 3130 -3960 3290 -3960 {
lab=n[28]}
N 3130 -3960 3130 -3490 {
lab=n[28]}
N 3110 -4110 3110 -3640 {
lab=n[27]}
N 3180 -4260 3290 -4260 {
lab=n[26]}
N 3180 -4260 3180 -3790 {
lab=n[26]}
N 3170 -3820 3290 -3820 {
lab=n[21]}
N 3120 -4410 3120 -3940 {
lab=n[25]}
N 3130 -4560 3130 -4090 {
lab=n[24]}
N 3140 -4710 3140 -4240 {
lab=n[23]}
N 3150 -4860 3150 -4390 {
lab=n[22]}
N 3030 -4540 3570 -4540 {
lab=n[21]}
N 3160 -5010 3160 -4540 {
lab=n[21]}
N 3200 -5160 3200 -4690 {
lab=n[20]}
N 3180 -4730 3290 -4730 {
lab=n[15]}
N 3210 -5310 3210 -4840 {
lab=n[19]}
N 3170 -4880 3290 -4880 {
lab=n[14]}
N 3230 -5470 3230 -4990 {
lab=n[18]}
N 3220 -5630 3220 -5150 {
lab=n[17]}
N 3220 -5150 3220 -5140 {
lab=n[17]}
N 3090 -7570 3090 -7100 {
lab=n[4]}
N 3240 -7430 3240 -6950 {
lab=n[5]}
N 3110 -7280 3290 -7280 {
lab=n[6]}
N 3110 -7280 3110 -6800 {
lab=n[6]}
N 3120 -7130 3120 -6650 {
lab=n[7]}
N 3130 -6990 3130 -6500 {
lab=n[8]}
N 3140 -6820 3140 -6350 {
lab=n[9]}
N 3150 -6670 3150 -6200 {
lab=n[10]}
N 3170 -6370 3170 -5900 {
lab=n[12]}
N 3160 -6520 3160 -6050 {
lab=n[11]}
N 3180 -6220 3180 -5750 {
lab=n[13]}
N 3190 -6080 3190 -5600 {
lab=n[14]}
N 3200 -5920 3200 -5440 {
lab=n[15]}
N 3210 -5780 3210 -5350 {
lab=n[16]}
N 3200 -5350 3210 -5350 {
lab=n[16]}
N 3200 -5350 3200 -5290 {
lab=n[16]}
N 3980 -4090 4090 -4090 {
lab=n[24]}
N 3980 -3940 4090 -3940 {
lab=n[25]}
N 3980 -3790 4090 -3790 {
lab=n[26]}
N 3980 -3640 4090 -3640 {
lab=n[27]}
N 3980 -3490 4090 -3490 {
lab=n[28]}
N 3980 -3340 4090 -3340 {
lab=n[29]}
N 3980 -3190 4090 -3190 {
lab=n[30]}
N 3980 -3040 4090 -3040 {
lab=n[31]}
N 3980 -5290 4090 -5290 {
lab=n[16]}
N 3980 -5140 4090 -5140 {
lab=n[17]}
N 3980 -4990 4090 -4990 {
lab=n[18]}
N 3980 -4840 4090 -4840 {
lab=n[19]}
N 3980 -4690 4090 -4690 {
lab=n[20]}
N 3980 -4540 4090 -4540 {
lab=n[21]}
N 3980 -4390 4090 -4390 {
lab=n[22]}
N 3980 -4240 4090 -4240 {
lab=n[23]}
N 3980 -6500 4090 -6500 {
lab=n[8]}
N 3980 -6350 4090 -6350 {
lab=n[9]}
N 3980 -6200 4090 -6200 {
lab=n[10]}
N 3980 -6050 4090 -6050 {
lab=n[11]}
N 3980 -5900 4090 -5900 {
lab=n[12]}
N 3980 -5750 4090 -5750 {
lab=n[13]}
N 3980 -5600 4090 -5600 {
lab=n[14]}
N 3980 -7700 4090 -7700 {
lab=n[0]}
N 3980 -7550 4090 -7550 {
lab=n[1]}
N 3980 -7400 4090 -7400 {
lab=n[2]}
N 3980 -7250 4090 -7250 {
lab=n[3]}
N 3980 -7100 4090 -7100 {
lab=n[4]}
N 3980 -6950 4090 -6950 {
lab=n[5]}
N 3980 -6800 4090 -6800 {
lab=n[6]}
N 3980 -6650 4090 -6650 {
lab=n[7]}
N 4090 -4090 4200 -4090 {
lab=n[24]}
N 4090 -3940 4200 -3940 {
lab=n[25]}
N 4090 -3790 4200 -3790 {
lab=n[26]}
N 4090 -3640 4200 -3640 {
lab=n[27]}
N 4090 -3490 4200 -3490 {
lab=n[28]}
N 4090 -3340 4200 -3340 {
lab=n[29]}
N 4090 -3190 4200 -3190 {
lab=n[30]}
N 4090 -3040 4200 -3040 {
lab=n[31]}
N 4090 -5290 4200 -5290 {
lab=n[16]}
N 4090 -5140 4200 -5140 {
lab=n[17]}
N 4090 -4990 4200 -4990 {
lab=n[18]}
N 4090 -4840 4200 -4840 {
lab=n[19]}
N 4090 -4690 4200 -4690 {
lab=n[20]}
N 4090 -4540 4200 -4540 {
lab=n[21]}
N 4090 -4390 4200 -4390 {
lab=n[22]}
N 4090 -4240 4200 -4240 {
lab=n[23]}
N 4090 -6500 4200 -6500 {
lab=n[8]}
N 4090 -6350 4200 -6350 {
lab=n[9]}
N 4090 -6200 4200 -6200 {
lab=n[10]}
N 4090 -6050 4200 -6050 {
lab=n[11]}
N 4090 -5900 4200 -5900 {
lab=n[12]}
N 4090 -5750 4200 -5750 {
lab=n[13]}
N 4090 -5600 4200 -5600 {
lab=n[14]}
N 4090 -7700 4200 -7700 {
lab=n[0]}
N 4090 -7550 4200 -7550 {
lab=n[1]}
N 4090 -7400 4200 -7400 {
lab=n[2]}
N 4090 -7250 4200 -7250 {
lab=n[3]}
N 4090 -7100 4200 -7100 {
lab=n[4]}
N 4090 -6950 4200 -6950 {
lab=n[5]}
N 4090 -6800 4200 -6800 {
lab=n[6]}
N 4090 -6650 4200 -6650 {
lab=n[7]}
N 4200 -7700 4260 -7700 {
lab=n[0]}
N 4200 -7550 4260 -7550 {
lab=n[1]}
N 4200 -7400 4260 -7400 {
lab=n[2]}
N 4200 -7250 4260 -7250 {
lab=n[3]}
N 4200 -7100 4260 -7100 {
lab=n[4]}
N 4200 -6950 4260 -6950 {
lab=n[5]}
N 4200 -6800 4260 -6800 {
lab=n[6]}
N 4200 -6650 4260 -6650 {
lab=n[7]}
N 4200 -6500 4260 -6500 {
lab=n[8]}
N 4200 -6350 4260 -6350 {
lab=n[9]}
N 4200 -6200 4260 -6200 {
lab=n[10]}
N 4200 -6050 4260 -6050 {
lab=n[11]}
N 4200 -5900 4260 -5900 {
lab=n[12]}
N 4200 -5750 4260 -5750 {
lab=n[13]}
N 4200 -5600 4260 -5600 {
lab=n[14]}
N 4200 -5440 4260 -5440 {
lab=n[15]}
N 4200 -5290 4260 -5290 {
lab=n[16]}
N 4200 -5140 4260 -5140 {
lab=n[17]}
N 4200 -4990 4260 -4990 {
lab=n[18]}
N 4200 -4840 4260 -4840 {
lab=n[19]}
N 4200 -4690 4260 -4690 {
lab=n[20]}
N 4200 -4540 4260 -4540 {
lab=n[21]}
N 4200 -4390 4260 -4390 {
lab=n[22]}
N 4200 -4240 4260 -4240 {
lab=n[23]}
N 4200 -4090 4260 -4090 {
lab=n[24]}
N 4200 -3940 4260 -3940 {
lab=n[25]}
N 4200 -3790 4260 -3790 {
lab=n[26]}
N 4200 -3640 4260 -3640 {
lab=n[27]}
N 4200 -3490 4260 -3490 {
lab=n[28]}
N 4200 -3340 4260 -3340 {
lab=n[29]}
N 4200 -3190 4260 -3190 {
lab=n[30]}
N 4200 -3040 4260 -3040 {
lab=n[31]}
N 4270 -7730 4270 -2970 {
lab=n[31:0]
bus=true}
N 3130 -6990 3290 -6990 {
lab=n[8]}
N 3980 -5440 4200 -5440 {
lab=n[15]}
N 2180 -7800 2180 -5490 {
lab=S0}
N 2180 -7760 2230 -7760 {
lab=S0}
N 2130 -7740 2230 -7740 {
lab=S1}
N 2180 -7610 2230 -7610 {
lab=S0}
N 2130 -7590 2230 -7590 {
lab=S1}
N 2180 -7460 2230 -7460 {
lab=S0}
N 2130 -7440 2230 -7440 {
lab=S1}
N 2180 -7310 2230 -7310 {
lab=S0}
N 2130 -7290 2230 -7290 {
lab=S1}
N 2180 -7160 2230 -7160 {
lab=S0}
N 2130 -7140 2230 -7140 {
lab=S1}
N 2180 -7010 2230 -7010 {
lab=S0}
N 2130 -6990 2230 -6990 {
lab=S1}
N 2180 -6860 2230 -6860 {
lab=S0}
N 2130 -6840 2230 -6840 {
lab=S1}
N 2180 -6710 2230 -6710 {
lab=S0}
N 2130 -6690 2230 -6690 {
lab=S1}
N 2180 -6560 2230 -6560 {
lab=S0}
N 2130 -6540 2230 -6540 {
lab=S1}
N 2180 -6410 2230 -6410 {
lab=S0}
N 2130 -6390 2230 -6390 {
lab=S1}
N 2180 -6260 2230 -6260 {
lab=S0}
N 2130 -6240 2230 -6240 {
lab=S1}
N 2180 -6110 2230 -6110 {
lab=S0}
N 2130 -6090 2230 -6090 {
lab=S1}
N 2180 -5960 2230 -5960 {
lab=S0}
N 2130 -5940 2230 -5940 {
lab=S1}
N 2180 -5810 2230 -5810 {
lab=S0}
N 2130 -5790 2230 -5790 {
lab=S1}
N 2180 -5660 2230 -5660 {
lab=S0}
N 2130 -5640 2230 -5640 {
lab=S1}
N 2180 -5540 2180 -3230 {
lab=S0}
N 2180 -5500 2230 -5500 {
lab=S0}
N 2130 -5480 2230 -5480 {
lab=S1}
N 2180 -5350 2230 -5350 {
lab=S0}
N 2130 -5330 2230 -5330 {
lab=S1}
N 2180 -5200 2230 -5200 {
lab=S0}
N 2130 -5180 2230 -5180 {
lab=S1}
N 2180 -5050 2230 -5050 {
lab=S0}
N 2130 -5030 2230 -5030 {
lab=S1}
N 2180 -4900 2230 -4900 {
lab=S0}
N 2130 -4880 2230 -4880 {
lab=S1}
N 2180 -4750 2230 -4750 {
lab=S0}
N 2130 -4730 2230 -4730 {
lab=S1}
N 2180 -4600 2230 -4600 {
lab=S0}
N 2130 -4580 2230 -4580 {
lab=S1}
N 2180 -4450 2230 -4450 {
lab=S0}
N 2130 -4430 2230 -4430 {
lab=S1}
N 2180 -4300 2230 -4300 {
lab=S0}
N 2130 -4280 2230 -4280 {
lab=S1}
N 2180 -4150 2230 -4150 {
lab=S0}
N 2130 -4130 2230 -4130 {
lab=S1}
N 2180 -4000 2230 -4000 {
lab=S0}
N 2130 -3980 2230 -3980 {
lab=S1}
N 2180 -3850 2230 -3850 {
lab=S0}
N 2130 -3830 2230 -3830 {
lab=S1}
N 2180 -3700 2230 -3700 {
lab=S0}
N 2130 -3680 2230 -3680 {
lab=S1}
N 2180 -3550 2230 -3550 {
lab=S0}
N 2130 -3530 2230 -3530 {
lab=S1}
N 2180 -3400 2230 -3400 {
lab=S0}
N 2130 -3380 2230 -3380 {
lab=S1}
N 1330 -7780 1330 -3220 {
lab=A[0]}
N 1250 -7780 1250 -3220 {
lab=A[2]}
N 1170 -7780 1170 -3220 {
lab=A[4]}
N 1090 -7780 1090 -3220 {
lab=A[6]}
N 1010 -7780 1010 -3220 {
lab=A[8]}
N 930 -7780 930 -3220 {
lab=A[10]}
N 850 -7780 850 -3220 {
lab=A[12]}
N 770 -7780 770 -3220 {
lab=A[14]}
N 690 -7780 690 -3220 {
lab=A[16]}
N 610 -7780 610 -3220 {
lab=A[18]}
N 530 -7780 530 -3220 {
lab=A[20]}
N 450 -7780 450 -3220 {
lab=A[22]}
N 370 -7780 370 -3220 {
lab=A[24]}
N 290 -7780 290 -3220 {
lab=A[26]}
N 210 -7780 210 -3220 {
lab=A[28]}
N 120 -7780 120 -3220 {
lab=A[30]}
N 650 -7780 650 -3220 {
lab=A[17]}
N 570 -7780 570 -3220 {
lab=A[19]}
N 490 -7780 490 -3220 {
lab=A[21]}
N 410 -7780 410 -3220 {
lab=A[23]}
N 330 -7780 330 -3220 {
lab=A[25]}
N 250 -7780 250 -3220 {
lab=A[27]}
N 170 -7780 170 -3220 {
lab=A[29]}
N 80 -7780 80 -3220 {
lab=A[31]}
N 730 -7780 730 -3220 {
lab=A[15]}
N 810 -7780 810 -3220 {
lab=A[13]}
N 890 -7780 890 -3220 {
lab=A[11]}
N 970 -7780 970 -3220 {
lab=A[9]}
N 1050 -7780 1050 -3220 {
lab=A[7]}
N 1130 -7780 1130 -3220 {
lab=A[5]}
N 1210 -7780 1210 -3220 {
lab=A[3]}
N 1290 -7780 1290 -3220 {
lab=A[1]}
N 1250 -7190 1640 -7190 {
lab=A[2]}
N 1210 -7050 1640 -7050 {
lab=A[3]}
N 2180 -3250 2230 -3250 {
lab=S0}
N 2180 -3100 2230 -3100 {
lab=S0}
N 2130 -3080 2230 -3080 {
lab=S1}
N 2130 -3240 2130 -3080 {
lab=S1}
N 2180 -3230 2180 -3100 {
lab=S0}
N 1290 -7610 1640 -7610 {
lab=A[1]}
N 1290 -7340 1680 -7340 {
lab=A[1]}
N 1170 -6880 1640 -6880 {
lab=A[4]}
N 1330 -7490 1720 -7490 {
lab=A[0]}
N 1130 -7030 1640 -7030 {
lab=A[5]}
N 1250 -7470 1680 -7470 {
lab=A[2]}
N 1210 -7320 1680 -7320 {
lab=A[3]}
N 1170 -7170 1680 -7170 {
lab=A[4]}
N 1090 -6860 1640 -6860 {
lab=A[6]}
N 70 -7790 1340 -7790 {
bus=true lab=A[31:0]}
N 2360 -7740 2420 -7740 {
lab=#net5}
N 2360 -7590 2420 -7590 {
lab=#net6}
N 2360 -7440 2420 -7440 {
lab=#net7}
N 2360 -7290 2420 -7290 {
lab=#net8}
N 2360 -7140 2420 -7140 {
lab=#net9}
N 2360 -6990 2420 -6990 {
lab=#net10}
N 2360 -6690 2420 -6690 {
lab=#net11}
N 2360 -6540 2420 -6540 {
lab=#net12}
N 2360 -6390 2420 -6390 {
lab=#net13}
N 2360 -6240 2420 -6240 {
lab=#net14}
N 2360 -6090 2420 -6090 {
lab=#net15}
N 2360 -5940 2420 -5940 {
lab=#net16}
N 2360 -5790 2420 -5790 {
lab=#net17}
N 2360 -5640 2420 -5640 {
lab=#net18}
N 2360 -5480 2420 -5480 {
lab=#net19}
N 2360 -5330 2420 -5330 {
lab=#net20}
N 2360 -5180 2420 -5180 {
lab=#net21}
N 2360 -5030 2420 -5030 {
lab=#net22}
N 2360 -4880 2420 -4880 {
lab=#net23}
N 2360 -4730 2420 -4730 {
lab=#net24}
N 2360 -4580 2420 -4580 {
lab=#net25}
N 2360 -4430 2420 -4430 {
lab=#net26}
N 2360 -4280 2420 -4280 {
lab=#net27}
N 2360 -4130 2420 -4130 {
lab=#net28}
N 2360 -3980 2420 -3980 {
lab=#net29}
N 2360 -3830 2420 -3830 {
lab=#net30}
N 2360 -3680 2420 -3680 {
lab=#net31}
N 2360 -3530 2420 -3530 {
lab=#net32}
N 2360 -3380 2420 -3380 {
lab=#net33}
N 2360 -3230 2420 -3230 {
lab=#net34}
N 2360 -3080 2420 -3080 {
lab=#net35}
N 1640 -7610 1790 -7610 {
lab=A[1]}
N 1720 -7490 1790 -7490 {
lab=A[0]}
N 1680 -7470 1790 -7470 {
lab=A[2]}
N 1680 -7340 1790 -7340 {
lab=A[1]}
N 1680 -7320 1790 -7320 {
lab=A[3]}
N 1680 -7170 1790 -7170 {
lab=A[4]}
N 1640 -7190 1790 -7190 {
lab=A[2]}
N 1640 -7050 1790 -7050 {
lab=A[3]}
N 1640 -6880 1790 -6880 {
lab=A[4]}
N 1130 -6730 1790 -6730 {
lab=A[5]}
N 1090 -6580 1790 -6580 {
lab=A[6]}
N 1050 -6430 1790 -6430 {
lab=A[7]}
N 1010 -6280 1790 -6280 {
lab=A[8]}
N 970 -6140 1790 -6140 {
lab=A[9]}
N 930 -5980 1790 -5980 {
lab=A[10]}
N 890 -5840 1790 -5840 {
lab=A[11]}
N 850 -5690 1790 -5690 {
lab=A[12]}
N 810 -5530 1790 -5530 {
lab=A[13]}
N 770 -5370 1790 -5370 {
lab=A[14]}
N 730 -5220 1790 -5220 {
lab=A[15]}
N 690 -5070 1790 -5070 {
lab=A[16]}
N 650 -4920 1790 -4920 {
lab=A[17]}
N 610 -4770 1790 -4770 {
lab=A[18]}
N 570 -4620 1790 -4620 {
lab=A[19]}
N 530 -4470 1790 -4470 {
lab=A[20]}
N 490 -4320 1790 -4320 {
lab=A[21]}
N 450 -4170 1790 -4170 {
lab=A[22]}
N 410 -4020 1790 -4020 {
lab=A[23]}
N 370 -3860 1790 -3860 {
lab=A[24]}
N 330 -3720 1790 -3720 {
lab=A[25]}
N 290 -3580 1790 -3580 {
lab=A[26]}
N 250 -3420 1790 -3420 {
lab=A[27]}
N 210 -3270 1790 -3270 {
lab=A[28]}
N 170 -3120 1790 -3120 {
lab=A[29]}
N 120 -2980 1790 -2980 {
lab=A[30]}
N 1640 -7030 1790 -7030 {
lab=A[5]}
N 1640 -6860 1780 -6860 {
lab=A[6]}
N 1780 -6860 1790 -6860 {
lab=A[6]}
N 1050 -6710 1710 -6710 {
lab=A[7]}
N 1010 -6560 1710 -6560 {
lab=A[8]}
N 970 -6410 1710 -6410 {
lab=A[9]}
N 930 -6260 1710 -6260 {
lab=A[10]}
N 890 -6120 1710 -6120 {
lab=A[11]}
N 850 -5960 1710 -5960 {
lab=A[12]}
N 810 -5820 1710 -5820 {
lab=A[13]}
N 770 -5670 1710 -5670 {
lab=A[14]}
N 730 -5510 1710 -5510 {
lab=A[15]}
N 690 -5350 1710 -5350 {
lab=A[16]}
N 650 -5200 1710 -5200 {
lab=A[17]}
N 610 -5050 1710 -5050 {
lab=A[18]}
N 570 -4900 1710 -4900 {
lab=A[19]}
N 530 -4750 1710 -4750 {
lab=A[20]}
N 490 -4600 1710 -4600 {
lab=A[21]}
N 450 -4450 1710 -4450 {
lab=A[22]}
N 410 -4300 1710 -4300 {
lab=A[23]}
N 370 -4150 1710 -4150 {
lab=A[24]}
N 330 -4000 1710 -4000 {
lab=A[25]}
N 290 -3840 1710 -3840 {
lab=A[26]}
N 250 -3700 1710 -3700 {
lab=A[27]}
N 210 -3560 1710 -3560 {
lab=A[28]}
N 170 -3400 1710 -3400 {
lab=A[29]}
N 130 -3250 1710 -3250 {
lab=A[30]}
N 90 -3100 1710 -3100 {
lab=A[31]}
N 1710 -6710 1790 -6710 {
lab=A[7]}
N 1710 -6560 1790 -6560 {
lab=A[8]}
N 1710 -6410 1790 -6410 {
lab=A[9]}
N 1710 -6260 1790 -6260 {
lab=A[10]}
N 1710 -6120 1790 -6120 {
lab=A[11]}
N 1710 -5960 1790 -5960 {
lab=A[12]}
N 1710 -5820 1790 -5820 {
lab=A[13]}
N 1710 -5670 1790 -5670 {
lab=A[14]}
N 1710 -5510 1790 -5510 {
lab=A[15]}
N 1710 -5350 1790 -5350 {
lab=A[16]}
N 1710 -5200 1790 -5200 {
lab=A[17]}
N 1710 -5050 1790 -5050 {
lab=A[18]}
N 1710 -4900 1790 -4900 {
lab=A[19]}
N 1710 -4750 1790 -4750 {
lab=A[20]}
N 1710 -4600 1790 -4600 {
lab=A[21]}
N 1710 -4450 1790 -4450 {
lab=A[22]}
N 1710 -4300 1790 -4300 {
lab=A[23]}
N 1710 -4150 1790 -4150 {
lab=A[24]}
N 1710 -4000 1790 -4000 {
lab=A[25]}
N 1710 -3840 1790 -3840 {
lab=A[26]}
N 1710 -3700 1790 -3700 {
lab=A[27]}
N 1710 -3560 1790 -3560 {
lab=A[28]}
N 1710 -2960 1790 -2960 {
lab=l}
N 1710 -3100 1790 -3100 {
lab=A[31]}
N 1710 -3250 1790 -3250 {
lab=A[30]}
N 1710 -3400 1790 -3400 {
lab=A[29]}
N 80 -4430 90 -4430 {
lab=A[31]}
N 120 -4530 130 -4530 {
lab=A[30]}
N 1330 -7710 2230 -7710 {
lab=A[0]}
N 1290 -7560 2230 -7560 {
lab=A[1]}
N 1250 -7410 2230 -7410 {
lab=A[2]}
N 1210 -7260 2230 -7260 {
lab=A[3]}
N 1170 -7110 2230 -7110 {
lab=A[4]}
N 1130 -6960 2230 -6960 {
lab=A[5]}
N 80 -3220 80 -2880 {
lab=A[31]}
N 120 -3220 120 -2880 {
lab=A[30]}
N 170 -3220 170 -2880 {
lab=A[29]}
N 210 -3220 210 -2880 {
lab=A[28]}
N 250 -3220 250 -2880 {
lab=A[27]}
N 290 -3220 290 -2880 {
lab=A[26]}
N 330 -3220 330 -2880 {
lab=A[25]}
N 370 -3220 370 -2880 {
lab=A[24]}
N 410 -3220 410 -2880 {
lab=A[23]}
N 450 -3220 450 -2880 {
lab=A[22]}
N 490 -3220 490 -2880 {
lab=A[21]}
N 530 -3220 530 -2880 {
lab=A[20]}
N 570 -3220 570 -2880 {
lab=A[19]}
N 610 -3220 610 -2880 {
lab=A[18]}
N 650 -3220 650 -2880 {
lab=A[17]}
N 690 -3220 690 -2880 {
lab=A[16]}
N 730 -3220 730 -2880 {
lab=A[15]}
N 770 -3220 770 -2880 {
lab=A[14]}
N 810 -3220 810 -2880 {
lab=A[13]}
N 850 -3220 850 -2880 {
lab=A[12]}
N 890 -3220 890 -2880 {
lab=A[11]}
N 930 -3220 930 -2880 {
lab=A[10]}
N 970 -3220 970 -2880 {
lab=A[9]}
N 1010 -3220 1010 -2880 {
lab=A[8]}
N 1050 -3220 1050 -2880 {
lab=A[7]}
N 1090 -3220 1090 -2880 {
lab=A[6]}
N 1130 -3220 1130 -2880 {
lab=A[5]}
N 1170 -3220 1170 -2880 {
lab=A[4]}
N 1210 -3220 1210 -2880 {
lab=A[3]}
N 1250 -3220 1250 -2880 {
lab=A[2]}
N 1290 -3220 1290 -2880 {
lab=A[1]}
N 1330 -3220 1330 -2880 {
lab=A[0]}
N 80 -3050 2230 -3050 {
lab=A[31]}
N 120 -3200 2230 -3200 {
lab=A[30]}
N 170 -3350 2230 -3350 {
lab=A[29]}
N 210 -3500 2230 -3500 {
lab=A[28]}
N 250 -3650 2230 -3650 {
lab=A[27]}
N 290 -3800 2230 -3800 {
lab=A[26]}
N 340 -3950 2230 -3950 {
lab=A[25]}
N 330 -3950 340 -3950 {
lab=A[25]}
N 370 -4100 2230 -4100 {
lab=A[24]}
N 410 -4250 2230 -4250 {
lab=A[23]}
N 450 -4400 2230 -4400 {
lab=A[22]}
N 490 -4550 2230 -4550 {
lab=A[21]}
N 530 -4700 2230 -4700 {
lab=A[20]}
N 610 -5000 2230 -5000 {
lab=A[18]}
N 570 -4850 2230 -4850 {
lab=A[19]}
N 650 -5150 2230 -5150 {
lab=A[17]}
N 690 -5300 2230 -5300 {
lab=A[16]}
N 730 -5450 2230 -5450 {
lab=A[15]}
N 770 -5610 2230 -5610 {
lab=A[14]}
N 810 -5760 2230 -5760 {
lab=A[13]}
N 860 -5910 2230 -5910 {
lab=A[12]}
N 850 -5910 860 -5910 {
lab=A[12]}
N 890 -6060 2230 -6060 {
lab=A[11]}
N 930 -6210 2230 -6210 {
lab=A[10]}
N 970 -6360 2230 -6360 {
lab=A[9]}
N 1010 -6510 2230 -6510 {
lab=A[8]}
N 1050 -6660 2230 -6660 {
lab=A[7]}
N 1090 -6810 2230 -6810 {
lab=A[6]}
N 1920 -7690 1920 -7660 {
lab=#net36}
N 1920 -7690 2230 -7690 {
lab=#net36}
N 1920 -7540 1920 -7520 {
lab=#net37}
N 1920 -7540 2230 -7540 {
lab=#net37}
N 1920 -7390 1920 -7370 {
lab=#net38}
N 1920 -7390 2230 -7390 {
lab=#net38}
N 1920 -7240 2230 -7240 {
lab=#net39}
N 1920 -7090 2230 -7090 {
lab=#net40}
N 1920 -6940 2230 -6940 {
lab=#net41}
N 1920 -6790 2230 -6790 {
lab=#net42}
N 1920 -6640 2230 -6640 {
lab=#net43}
N 1920 -6490 2230 -6490 {
lab=#net44}
N 1920 -6340 2230 -6340 {
lab=#net45}
N 1920 -6190 2230 -6190 {
lab=#net46}
N 1920 -6040 2230 -6040 {
lab=#net47}
N 1920 -5890 2230 -5890 {
lab=#net48}
N 1920 -5740 2230 -5740 {
lab=#net49}
N 1920 -5590 2230 -5590 {
lab=#net50}
N 1920 -5430 2230 -5430 {
lab=#net51}
N 1920 -5280 2230 -5280 {
lab=#net52}
N 1920 -5130 2230 -5130 {
lab=#net53}
N 1920 -4980 2230 -4980 {
lab=#net54}
N 1920 -4830 2230 -4830 {
lab=#net55}
N 1920 -4680 2230 -4680 {
lab=#net56}
N 1920 -4530 2230 -4530 {
lab=#net57}
N 1920 -4380 2230 -4380 {
lab=#net58}
N 1920 -4230 2230 -4230 {
lab=#net59}
N 1920 -4080 2230 -4080 {
lab=#net60}
N 1920 -3930 2230 -3930 {
lab=#net61}
N 1920 -3780 2230 -3780 {
lab=#net62}
N 1920 -3630 2230 -3630 {
lab=#net63}
N 1920 -3480 2230 -3480 {
lab=#net64}
N 1920 -3330 2230 -3330 {
lab=#net65}
N 1920 -3180 2230 -3180 {
lab=#net66}
N 1920 -3030 2230 -3030 {
lab=#net67}
N 1920 -3030 1920 -3010 {
lab=#net67}
N 1920 -3180 1920 -3150 {
lab=#net66}
N 1920 -3330 1920 -3300 {
lab=#net65}
N 1920 -3480 1920 -3450 {
lab=#net64}
N 1920 -3630 1920 -3610 {
lab=#net63}
N 1920 -3780 1920 -3750 {
lab=#net62}
N 1920 -3930 1920 -3890 {
lab=#net61}
N 1920 -4080 1920 -4050 {
lab=#net60}
N 1920 -4230 1920 -4200 {
lab=#net59}
N 1920 -4380 1920 -4350 {
lab=#net58}
N 1920 -4530 1920 -4500 {
lab=#net57}
N 1920 -4680 1920 -4650 {
lab=#net56}
N 1920 -4830 1920 -4800 {
lab=#net55}
N 1920 -4980 1920 -4950 {
lab=#net54}
N 1920 -5130 1920 -5100 {
lab=#net53}
N 1920 -5280 1920 -5250 {
lab=#net52}
N 1920 -5430 1920 -5400 {
lab=#net51}
N 1920 -5590 1920 -5560 {
lab=#net50}
N 1920 -5740 1920 -5720 {
lab=#net49}
N 1920 -5890 1920 -5870 {
lab=#net48}
N 1920 -6040 1920 -6010 {
lab=#net47}
N 1920 -6190 1920 -6170 {
lab=#net46}
N 1920 -6340 1920 -6310 {
lab=#net45}
N 1920 -6490 1920 -6460 {
lab=#net44}
N 1920 -6640 1920 -6610 {
lab=#net43}
N 1920 -6790 1920 -6760 {
lab=#net42}
N 1920 -6940 1920 -6910 {
lab=#net41}
N 1920 -7090 1920 -7080 {
lab=#net40}
N 1920 -7240 1920 -7220 {
lab=#net39}
N 1930 -7670 2230 -7670 {
lab=#net37}
N 1930 -7670 1930 -7540 {
lab=#net37}
N 1930 -7520 2230 -7520 {
lab=#net38}
N 1930 -7520 1930 -7390 {
lab=#net38}
N 1930 -7370 2230 -7370 {
lab=#net39}
N 1930 -7370 1930 -7240 {
lab=#net39}
N 1930 -7220 2230 -7220 {
lab=#net40}
N 1930 -7220 1930 -7090 {
lab=#net40}
N 1930 -7070 2230 -7070 {
lab=#net41}
N 1930 -6920 2230 -6920 {
lab=#net42}
N 1930 -6770 2230 -6770 {
lab=#net43}
N 1930 -6620 2230 -6620 {
lab=#net44}
N 1930 -6470 2230 -6470 {
lab=#net45}
N 1930 -6320 2230 -6320 {
lab=#net46}
N 1930 -6170 2230 -6170 {
lab=#net47}
N 1930 -6020 2230 -6020 {
lab=#net48}
N 1930 -5870 2230 -5870 {
lab=#net49}
N 1930 -5720 2230 -5720 {
lab=#net50}
N 1930 -5570 2230 -5570 {
lab=#net51}
N 1930 -5410 2230 -5410 {
lab=#net52}
N 1930 -5260 2230 -5260 {
lab=#net53}
N 1930 -5110 2230 -5110 {
lab=#net54}
N 1930 -4960 2230 -4960 {
lab=#net55}
N 1930 -4810 2230 -4810 {
lab=#net56}
N 1930 -4660 2230 -4660 {
lab=#net57}
N 1930 -4510 2230 -4510 {
lab=#net58}
N 1930 -4360 2230 -4360 {
lab=#net59}
N 1930 -4210 2230 -4210 {
lab=#net60}
N 1930 -4060 2230 -4060 {
lab=#net61}
N 1930 -3910 2230 -3910 {
lab=#net62}
N 1930 -3760 2230 -3760 {
lab=#net63}
N 1930 -3610 2230 -3610 {
lab=#net64}
N 1930 -3460 2230 -3460 {
lab=#net65}
N 1930 -3310 2230 -3310 {
lab=#net66}
N 1930 -3160 2230 -3160 {
lab=#net67}
N 1930 -3160 1930 -3030 {
lab=#net67}
N 1930 -3310 1930 -3180 {
lab=#net66}
N 1930 -3460 1930 -3330 {
lab=#net65}
N 1930 -3910 1930 -3780 {
lab=#net62}
N 1930 -3760 1930 -3630 {
lab=#net63}
N 1930 -3610 1930 -3480 {
lab=#net64}
N 1930 -4060 1930 -3930 {
lab=#net61}
N 1930 -4210 1930 -4080 {
lab=#net60}
N 1930 -4360 1930 -4230 {
lab=#net59}
N 1930 -4510 1930 -4380 {
lab=#net58}
N 1930 -4660 1930 -4530 {
lab=#net57}
N 1930 -4810 1930 -4680 {
lab=#net56}
N 1930 -4960 1930 -4830 {
lab=#net55}
N 1930 -5110 1930 -4980 {
lab=#net54}
N 1930 -5260 1930 -5130 {
lab=#net53}
N 1930 -5410 1930 -5280 {
lab=#net52}
N 1930 -5570 1930 -5430 {
lab=#net51}
N 1930 -5720 1930 -5590 {
lab=#net50}
N 1930 -5870 1930 -5740 {
lab=#net49}
N 1930 -6020 1930 -5890 {
lab=#net48}
N 1930 -6170 1930 -6050 {
lab=#net47}
N 1930 -6050 1930 -6040 {
lab=#net47}
N 1930 -6320 1930 -6190 {
lab=#net46}
N 1930 -6470 1930 -6340 {
lab=#net45}
N 1930 -6620 1930 -6490 {
lab=#net44}
N 1930 -6770 1930 -6640 {
lab=#net43}
N 1930 -6920 1930 -6790 {
lab=#net42}
N 1930 -7070 1930 -6940 {
lab=#net41}
N 1940 -7650 2230 -7650 {
lab=#net38}
N 1940 -7650 1940 -7390 {
lab=#net38}
N 1950 -7500 2230 -7500 {
lab=#net39}
N 1950 -7500 1950 -7240 {
lab=#net39}
N 1960 -7350 2230 -7350 {
lab=#net40}
N 1960 -7350 1960 -7090 {
lab=#net40}
N 1970 -7200 2230 -7200 {
lab=#net41}
N 1970 -7200 1970 -6940 {
lab=#net41}
N 1980 -7050 2230 -7050 {
lab=#net42}
N 1980 -7050 1980 -6790 {
lab=#net42}
N 1990 -6900 2230 -6900 {
lab=#net43}
N 1990 -6900 1990 -6640 {
lab=#net43}
N 2000 -6750 2230 -6750 {
lab=#net44}
N 2000 -6750 2000 -6490 {
lab=#net44}
N 2010 -6600 2230 -6600 {
lab=#net45}
N 2010 -6600 2010 -6340 {
lab=#net45}
N 2020 -6450 2230 -6450 {
lab=#net46}
N 2020 -6450 2020 -6190 {
lab=#net46}
N 2030 -6300 2230 -6300 {
lab=#net47}
N 2030 -6300 2030 -6040 {
lab=#net47}
N 2040 -6150 2230 -6150 {
lab=#net48}
N 2040 -6150 2040 -5890 {
lab=#net48}
N 2050 -6000 2230 -6000 {
lab=#net49}
N 2050 -6000 2050 -5740 {
lab=#net49}
N 2060 -5850 2230 -5850 {
lab=#net50}
N 2060 -5850 2060 -5590 {
lab=#net50}
N 2070 -5700 2230 -5700 {
lab=#net51}
N 2070 -5700 2070 -5430 {
lab=#net51}
N 2080 -5550 2230 -5550 {
lab=#net52}
N 2080 -5550 2080 -5280 {
lab=#net52}
N 2090 -5390 2230 -5390 {
lab=#net53}
N 2090 -5390 2090 -5130 {
lab=#net53}
N 2100 -5240 2230 -5240 {
lab=#net54}
N 2100 -5240 2100 -4980 {
lab=#net54}
N 2090 -5090 2230 -5090 {
lab=#net55}
N 2090 -5090 2090 -4830 {
lab=#net55}
N 2130 -7800 2130 -3230 {
lab=S1}
N 2080 -4940 2230 -4940 {
lab=#net56}
N 2080 -4940 2080 -4680 {
lab=#net56}
N 2070 -4790 2230 -4790 {
lab=#net57}
N 2070 -4790 2070 -4530 {
lab=#net57}
N 2060 -4640 2230 -4640 {
lab=#net58}
N 2060 -4640 2060 -4380 {
lab=#net58}
N 2050 -4490 2230 -4490 {
lab=#net59}
N 2050 -4490 2050 -4230 {
lab=#net59}
N 2040 -4340 2230 -4340 {
lab=#net60}
N 2040 -4340 2040 -4080 {
lab=#net60}
N 2030 -4190 2230 -4190 {
lab=#net61}
N 2030 -4190 2030 -3930 {
lab=#net61}
N 2020 -4040 2230 -4040 {
lab=#net62}
N 2020 -4040 2020 -3780 {
lab=#net62}
N 2010 -3890 2230 -3890 {
lab=#net63}
N 2010 -3890 2010 -3630 {
lab=#net63}
N 2000 -3740 2230 -3740 {
lab=#net64}
N 2000 -3740 2000 -3480 {
lab=#net64}
N 1990 -3590 2230 -3590 {
lab=#net65}
N 1990 -3590 1990 -3330 {
lab=#net65}
N 1980 -3440 2230 -3440 {
lab=#net66}
N 1980 -3440 1980 -3180 {
lab=#net66}
N 1970 -3290 2230 -3290 {
lab=#net67}
N 1970 -3290 1970 -3030 {
lab=#net67}
N 1710 -2960 1710 -2760 {
lab=l}
N 1750 -5320 1750 -3010 {
lab=S}
N 1750 -7620 1750 -5310 {
lab=S}
N 1750 -7750 1750 -7620 {
lab=S}
N 1770 -7630 1790 -7630 {
lab=l}
N 1770 -7740 1770 -7630 {
lab=l}
N 1750 -7660 1790 -7660 {
lab=S}
N 1750 -7520 1790 -7520 {
lab=S}
N 1750 -7370 1790 -7370 {
lab=S}
N 1750 -7220 1790 -7220 {
lab=S}
N 1750 -7080 1790 -7080 {
lab=S}
N 1750 -6910 1790 -6910 {
lab=S}
N 1750 -6760 1790 -6760 {
lab=S}
N 1750 -6610 1790 -6610 {
lab=S}
N 1750 -6460 1790 -6460 {
lab=S}
N 1750 -6310 1790 -6310 {
lab=S}
N 1750 -6170 1790 -6170 {
lab=S}
N 1750 -6010 1790 -6010 {
lab=S}
N 1750 -5870 1790 -5870 {
lab=S}
N 1750 -5720 1790 -5720 {
lab=S}
N 1750 -5560 1790 -5560 {
lab=S}
N 1750 -5400 1790 -5400 {
lab=S}
N 1750 -5250 1790 -5250 {
lab=S}
N 1750 -5100 1790 -5100 {
lab=S}
N 1750 -4950 1790 -4950 {
lab=S}
N 1750 -4800 1790 -4800 {
lab=S}
N 1750 -4650 1790 -4650 {
lab=S}
N 1750 -4500 1790 -4500 {
lab=S}
N 1750 -4350 1790 -4350 {
lab=S}
N 1750 -4200 1790 -4200 {
lab=S}
N 1750 -4050 1790 -4050 {
lab=S}
N 1750 -3890 1790 -3890 {
lab=S}
N 1750 -3750 1790 -3750 {
lab=S}
N 1750 -3610 1790 -3610 {
lab=S}
N 1750 -3450 1790 -3450 {
lab=S}
N 1750 -3300 1790 -3300 {
lab=S}
N 1750 -3150 1790 -3150 {
lab=S}
N 1750 -3010 1790 -3010 {
lab=S}
N 2420 -7740 2480 -7740 {
lab=#net5}
N 2420 -7590 2480 -7590 {
lab=#net6}
N 2420 -7440 2480 -7440 {
lab=#net7}
N 2420 -7290 2480 -7290 {
lab=#net8}
N 2420 -7140 2480 -7140 {
lab=#net9}
N 2420 -6990 2480 -6990 {
lab=#net10}
N 2420 -6690 2480 -6690 {
lab=#net11}
N 2420 -6540 2480 -6540 {
lab=#net12}
N 2420 -6390 2480 -6390 {
lab=#net13}
N 2420 -6240 2480 -6240 {
lab=#net14}
N 2420 -6090 2480 -6090 {
lab=#net15}
N 2420 -5790 2480 -5790 {
lab=#net17}
N 2420 -5640 2480 -5640 {
lab=#net18}
N 2420 -5480 2480 -5480 {
lab=#net19}
N 2420 -5330 2480 -5330 {
lab=#net20}
N 2420 -5180 2480 -5180 {
lab=#net21}
N 2420 -5030 2480 -5030 {
lab=#net22}
N 2420 -4880 2480 -4880 {
lab=#net23}
N 2420 -4730 2480 -4730 {
lab=#net24}
N 2420 -4580 2480 -4580 {
lab=#net25}
N 2420 -4430 2480 -4430 {
lab=#net26}
N 2420 -4280 2480 -4280 {
lab=#net27}
N 2420 -4130 2480 -4130 {
lab=#net28}
N 2420 -3980 2480 -3980 {
lab=#net29}
N 2420 -3830 2480 -3830 {
lab=#net30}
N 2420 -3680 2480 -3680 {
lab=#net31}
N 2420 -3380 2480 -3380 {
lab=#net33}
N 2420 -3230 2480 -3230 {
lab=#net34}
N 2420 -3080 2480 -3080 {
lab=#net35}
N 80 -3100 90 -3100 {
lab=A[31]}
N 120 -3250 130 -3250 {
lab=A[30]}
N 2110 -3140 2230 -3140 {
lab=l}
N 2110 -3140 2110 -2990 {
lab=l}
N 2110 -2990 2230 -2990 {
lab=l}
N 2110 -2990 2110 -2910 {
lab=l}
N 2110 -3010 2230 -3010 {
lab=l}
N 2200 -3230 2230 -3230 {
lab=S1}
N 2200 -3230 2200 -3220 {
lab=S1}
N 2130 -3220 2200 -3220 {
lab=S1}
N 2610 -6860 2620 -6860 {
lab=#net68}
N 2750 -7690 2750 -7660 {
lab=#net69}
N 2750 -7540 2750 -7520 {
lab=#net70}
N 2750 -7390 2750 -7370 {
lab=#net71}
N 2750 -3030 2750 -3010 {
lab=#net72}
N 2750 -3180 2750 -3150 {
lab=#net73}
N 2750 -3330 2750 -3300 {
lab=#net74}
N 2750 -3480 2750 -3450 {
lab=#net75}
N 2750 -3630 2750 -3610 {
lab=#net76}
N 2750 -3780 2750 -3750 {
lab=#net77}
N 2750 -3930 2750 -3890 {
lab=#net78}
N 2750 -4080 2750 -4050 {
lab=#net79}
N 2750 -4230 2750 -4200 {
lab=#net80}
N 2750 -4380 2750 -4350 {
lab=#net81}
N 2750 -4530 2750 -4500 {
lab=#net82}
N 2750 -4680 2750 -4650 {
lab=#net83}
N 2750 -4830 2750 -4800 {
lab=#net84}
N 2750 -4980 2750 -4950 {
lab=#net85}
N 2750 -5130 2750 -5100 {
lab=#net86}
N 2750 -5280 2750 -5250 {
lab=#net87}
N 2750 -5430 2750 -5400 {
lab=#net88}
N 2750 -5590 2750 -5560 {
lab=#net89}
N 2750 -5740 2750 -5720 {
lab=#net90}
N 2750 -5890 2750 -5870 {
lab=#net91}
N 2750 -6040 2750 -6010 {
lab=#net92}
N 2750 -6190 2750 -6170 {
lab=#net93}
N 2750 -6340 2750 -6310 {
lab=#net94}
N 2750 -6490 2750 -6460 {
lab=#net95}
N 2750 -6640 2750 -6610 {
lab=#net96}
N 2750 -6790 2750 -6760 {
lab=#net97}
N 2750 -6940 2750 -6910 {
lab=#net98}
N 2750 -7090 2750 -7080 {
lab=#net99}
N 2750 -7240 2750 -7220 {
lab=#net100}
N 2580 -5320 2580 -3010 {
lab=S}
N 2580 -7620 2580 -5310 {
lab=S}
N 2580 -7750 2580 -7620 {
lab=S}
N 2600 -7630 2620 -7630 {
lab=l}
N 2580 -7660 2620 -7660 {
lab=S}
N 2580 -7520 2620 -7520 {
lab=S}
N 2580 -7370 2620 -7370 {
lab=S}
N 2580 -7220 2620 -7220 {
lab=S}
N 2580 -7080 2620 -7080 {
lab=S}
N 2580 -6910 2620 -6910 {
lab=S}
N 2580 -6760 2620 -6760 {
lab=S}
N 2580 -6610 2620 -6610 {
lab=S}
N 2580 -6460 2620 -6460 {
lab=S}
N 2580 -6310 2620 -6310 {
lab=S}
N 2580 -6170 2620 -6170 {
lab=S}
N 2580 -6010 2620 -6010 {
lab=S}
N 2580 -5870 2620 -5870 {
lab=S}
N 2580 -5720 2620 -5720 {
lab=S}
N 2580 -5560 2620 -5560 {
lab=S}
N 2580 -5400 2620 -5400 {
lab=S}
N 2580 -5250 2620 -5250 {
lab=S}
N 2580 -5100 2620 -5100 {
lab=S}
N 2580 -4950 2620 -4950 {
lab=S}
N 2580 -4800 2620 -4800 {
lab=S}
N 2580 -4650 2620 -4650 {
lab=S}
N 2580 -4500 2620 -4500 {
lab=S}
N 2580 -4350 2620 -4350 {
lab=S}
N 2580 -4200 2620 -4200 {
lab=S}
N 2580 -4050 2620 -4050 {
lab=S}
N 2580 -3890 2620 -3890 {
lab=S}
N 2580 -3750 2620 -3750 {
lab=S}
N 2580 -3610 2620 -3610 {
lab=S}
N 2580 -3450 2620 -3450 {
lab=S}
N 2580 -3300 2620 -3300 {
lab=S}
N 2580 -3150 2620 -3150 {
lab=S}
N 2580 -3010 2620 -3010 {
lab=S}
N 2580 -7800 2580 -7750 {
lab=S}
N 2370 -7490 2620 -7490 {
lab=#net5}
N 2370 -7740 2370 -7490 {
lab=#net5}
N 2380 -7590 2380 -7340 {
lab=#net6}
N 2380 -7340 2620 -7340 {
lab=#net6}
N 2390 -7440 2390 -7190 {
lab=#net7}
N 2390 -7190 2620 -7190 {
lab=#net7}
N 2400 -7050 2620 -7050 {
lab=#net8}
N 2410 -6880 2620 -6880 {
lab=#net9}
N 2420 -6730 2630 -6730 {
lab=#net10}
N 2420 -6990 2420 -6730 {
lab=#net10}
N 2430 -6840 2430 -6580 {
lab=#net101}
N 2430 -6580 2620 -6580 {
lab=#net101}
N 2440 -6430 2620 -6430 {
lab=#net11}
N 2450 -6540 2450 -6280 {
lab=#net12}
N 2450 -6280 2620 -6280 {
lab=#net12}
N 2460 -6390 2460 -6140 {
lab=#net13}
N 2460 -6140 2620 -6140 {
lab=#net13}
N 2470 -6240 2470 -5980 {
lab=#net14}
N 2470 -5980 2620 -5980 {
lab=#net14}
N 2480 -5840 2620 -5840 {
lab=#net15}
N 2480 -6090 2480 -5840 {
lab=#net15}
N 2490 -5940 2490 -5690 {
lab=#net102}
N 2490 -5690 2620 -5690 {
lab=#net102}
N 2500 -5790 2500 -5530 {
lab=#net103}
N 2500 -5530 2620 -5530 {
lab=#net103}
N 2510 -5370 2620 -5370 {
lab=#net104}
N 2510 -5640 2510 -5370 {
lab=#net104}
N 2520 -5480 2520 -5220 {
lab=#net105}
N 2520 -5220 2620 -5220 {
lab=#net105}
N 2530 -5330 2530 -5070 {
lab=#net106}
N 2530 -5070 2620 -5070 {
lab=#net106}
N 2540 -5180 2540 -4920 {
lab=#net107}
N 2540 -4920 2620 -4920 {
lab=#net107}
N 2550 -5030 2550 -4770 {
lab=#net108}
N 2550 -4770 2620 -4770 {
lab=#net108}
N 2560 -4880 2560 -4620 {
lab=#net109}
N 2560 -4620 2620 -4620 {
lab=#net109}
N 2550 -4470 2620 -4470 {
lab=#net110}
N 2550 -4730 2550 -4470 {
lab=#net110}
N 2540 -4320 2620 -4320 {
lab=#net111}
N 2540 -4580 2540 -4320 {
lab=#net111}
N 2530 -4170 2620 -4170 {
lab=#net112}
N 2530 -4430 2530 -4170 {
lab=#net112}
N 2520 -4020 2620 -4020 {
lab=#net113}
N 2520 -4280 2520 -4020 {
lab=#net113}
N 2510 -3860 2620 -3860 {
lab=#net114}
N 2510 -4130 2510 -3860 {
lab=#net114}
N 2500 -3720 2620 -3720 {
lab=#net115}
N 2500 -3980 2500 -3720 {
lab=#net115}
N 2490 -3580 2620 -3580 {
lab=#net116}
N 2490 -3830 2490 -3580 {
lab=#net116}
N 2480 -3420 2620 -3420 {
lab=#net31}
N 2480 -3680 2480 -3420 {
lab=#net31}
N 2470 -3270 2620 -3270 {
lab=#net117}
N 2470 -3530 2470 -3270 {
lab=#net117}
N 2460 -3120 2620 -3120 {
lab=#net33}
N 2460 -3380 2460 -3120 {
lab=#net33}
N 2450 -2980 2620 -2980 {
lab=#net34}
N 2450 -3230 2450 -2980 {
lab=#net34}
N 2750 -5440 2750 -5430 {
lab=#net88}
N 2540 -2960 2620 -2960 {
lab=l}
N 2540 -2960 2540 -2760 {
lab=l}
N 2570 -3100 2620 -3100 {
lab=#net118}
N 2570 -3100 2570 -3080 {
lab=#net118}
N 2570 -3250 2620 -3250 {
lab=#net119}
N 2570 -3250 2570 -3230 {
lab=#net119}
N 2570 -3400 2620 -3400 {
lab=#net120}
N 2570 -3400 2570 -3380 {
lab=#net120}
N 2570 -3560 2620 -3560 {
lab=#net121}
N 2570 -3560 2570 -3530 {
lab=#net121}
N 2570 -3700 2620 -3700 {
lab=#net122}
N 2570 -3700 2570 -3680 {
lab=#net122}
N 2570 -3840 2620 -3840 {
lab=#net123}
N 2570 -3840 2570 -3830 {
lab=#net123}
N 2570 -4000 2620 -4000 {
lab=#net124}
N 2570 -4000 2570 -3980 {
lab=#net124}
N 2570 -4150 2620 -4150 {
lab=#net125}
N 2570 -4150 2570 -4130 {
lab=#net125}
N 2570 -4300 2620 -4300 {
lab=#net126}
N 2570 -4300 2570 -4280 {
lab=#net126}
N 2570 -4450 2620 -4450 {
lab=#net127}
N 2570 -4450 2570 -4430 {
lab=#net127}
N 2570 -4600 2620 -4600 {
lab=#net128}
N 2570 -4600 2570 -4580 {
lab=#net128}
N 2570 -4750 2620 -4750 {
lab=#net129}
N 2570 -4750 2570 -4730 {
lab=#net129}
N 2570 -4900 2620 -4900 {
lab=#net130}
N 2570 -4900 2570 -4880 {
lab=#net130}
N 2570 -5050 2620 -5050 {
lab=#net131}
N 2570 -5050 2570 -5030 {
lab=#net131}
N 2570 -5200 2620 -5200 {
lab=#net132}
N 2570 -5200 2570 -5180 {
lab=#net132}
N 2570 -5350 2620 -5350 {
lab=#net133}
N 2570 -5350 2570 -5330 {
lab=#net133}
N 2570 -5510 2620 -5510 {
lab=#net134}
N 2570 -5510 2570 -5480 {
lab=#net134}
N 2570 -5670 2620 -5670 {
lab=#net135}
N 2570 -5670 2570 -5640 {
lab=#net135}
N 2570 -5820 2620 -5820 {
lab=#net136}
N 2570 -5820 2570 -5790 {
lab=#net136}
N 2570 -5960 2620 -5960 {
lab=#net137}
N 2570 -5960 2570 -5940 {
lab=#net137}
N 2570 -6120 2620 -6120 {
lab=#net138}
N 2570 -6120 2570 -6090 {
lab=#net138}
N 2570 -6260 2620 -6260 {
lab=#net139}
N 2570 -6260 2570 -6240 {
lab=#net139}
N 2570 -6410 2620 -6410 {
lab=#net140}
N 2570 -6410 2570 -6390 {
lab=#net140}
N 2570 -6560 2620 -6560 {
lab=#net141}
N 2570 -6560 2570 -6540 {
lab=#net141}
N 2570 -6710 2620 -6710 {
lab=#net142}
N 2570 -6710 2570 -6690 {
lab=#net142}
N 2570 -6860 2610 -6860 {
lab=#net68}
N 2570 -6860 2570 -6840 {
lab=#net68}
N 2570 -7030 2620 -7030 {
lab=#net143}
N 2570 -7030 2570 -6990 {
lab=#net143}
N 2560 -7170 2620 -7170 {
lab=#net144}
N 2560 -7170 2560 -7140 {
lab=#net144}
N 2570 -7320 2620 -7320 {
lab=#net145}
N 2570 -7320 2570 -7290 {
lab=#net145}
N 2570 -7470 2620 -7470 {
lab=#net146}
N 2570 -7470 2570 -7440 {
lab=#net146}
N 2560 -7610 2620 -7610 {
lab=#net147}
N 2560 -7610 2560 -7590 {
lab=#net147}
N 2600 -7810 2600 -7630 {
lab=l}
N 2440 -6690 2440 -6430 {
lab=#net11}
N 2410 -7140 2410 -6880 {
lab=#net9}
N 2400 -7290 2400 -7050 {
lab=#net8}
C {2x1_mux.sym} 3350 -7590 0 0 {name=x65}
C {2x1_mux.sym} 3350 -7450 0 0 {name=x66}
C {2x1_mux.sym} 3350 -7300 0 0 {name=x99}
C {2x1_mux.sym} 3350 -7150 0 0 {name=x100}
C {2x1_mux.sym} 3350 -7010 0 0 {name=x101}
C {2x1_mux.sym} 3350 -6840 0 0 {name=x102}
C {2x1_mux.sym} 3350 -6690 0 0 {name=x103}
C {2x1_mux.sym} 3350 -6540 0 0 {name=x104}
C {2x1_mux.sym} 3350 -6390 0 0 {name=x105}
C {2x1_mux.sym} 3350 -6240 0 0 {name=x106}
C {2x1_mux.sym} 3350 -6100 0 0 {name=x107}
C {2x1_mux.sym} 3350 -5940 0 0 {name=x108}
C {2x1_mux.sym} 3350 -5800 0 0 {name=x109}
C {2x1_mux.sym} 3350 -5650 0 0 {name=x110}
C {2x1_mux.sym} 3350 -5490 0 0 {name=x111}
C {2x1_mux.sym} 3350 -5330 0 0 {name=x112}
C {2x1_mux.sym} 3350 -5180 0 0 {name=x113}
C {2x1_mux.sym} 3350 -5030 0 0 {name=x114}
C {2x1_mux.sym} 3350 -4880 0 0 {name=x115}
C {2x1_mux.sym} 3350 -4730 0 0 {name=x116}
C {2x1_mux.sym} 3350 -4580 0 0 {name=x117}
C {2x1_mux.sym} 3350 -4430 0 0 {name=x118}
C {2x1_mux.sym} 3350 -4280 0 0 {name=x119}
C {2x1_mux.sym} 3350 -4130 0 0 {name=x120}
C {2x1_mux.sym} 3350 -3980 0 0 {name=x121}
C {2x1_mux.sym} 3350 -3820 0 0 {name=x122}
C {2x1_mux.sym} 3350 -3680 0 0 {name=x123}
C {2x1_mux.sym} 3350 -3540 0 0 {name=x124}
C {2x1_mux.sym} 3350 -3380 0 0 {name=x125}
C {2x1_mux.sym} 3350 -3230 0 0 {name=x126}
C {2x1_mux.sym} 3350 -3080 0 0 {name=x127}
C {2x1_mux.sym} 3350 -2940 0 0 {name=x128}
C {devices/ipin.sym} 3250 -7760 1 0 {name=p6 sig_type=std_logic lab=S}
C {devices/ipin.sym} 3270 -7770 1 0 {name=p7 sig_type=std_logic lab=l}
C {devices/ipin.sym} 3210 -2720 3 0 {name=p9 sig_type=std_logic lab=l}
C {devices/bus_tap.sym} 4380 -7640 0 1 {name=l65 lab=[0]}
C {devices/bus_tap.sym} 4380 -7490 0 1 {name=l66 lab=[1]}
C {devices/bus_tap.sym} 4380 -7340 0 1 {name=l67 lab=[2]}
C {devices/bus_tap.sym} 4380 -7190 0 1 {name=l68 lab=[3]}
C {devices/bus_tap.sym} 4380 -7040 0 1 {name=l69 lab=[4]}
C {devices/bus_tap.sym} 4380 -6890 0 1 {name=l70 lab=[5]}
C {devices/bus_tap.sym} 4380 -6740 0 1 {name=l71 lab=[6]}
C {devices/bus_tap.sym} 4380 -6590 0 1 {name=l72 lab=[7]}
C {devices/bus_tap.sym} 4380 -6440 0 1 {name=l73 lab=[8]}
C {devices/bus_tap.sym} 4380 -6290 0 1 {name=l74 lab=[9]}
C {devices/bus_tap.sym} 4380 -6140 0 1 {name=l75 lab=[10]}
C {devices/bus_tap.sym} 4380 -5990 0 1 {name=l76 lab=[11]}
C {devices/bus_tap.sym} 4380 -5840 0 1 {name=l77 lab=[12]}
C {devices/bus_tap.sym} 4380 -5690 0 1 {name=l78 lab=[13]}
C {devices/bus_tap.sym} 4380 -5540 0 1 {name=l79 lab=[14]}
C {devices/bus_tap.sym} 4380 -5380 0 1 {name=l80 lab=[15]}
C {devices/bus_tap.sym} 4380 -5230 0 1 {name=l81 lab=[16]}
C {devices/bus_tap.sym} 4380 -5080 0 1 {name=l82 lab=[17]}
C {devices/bus_tap.sym} 4380 -4930 0 1 {name=l83 lab=[18]}
C {devices/bus_tap.sym} 4380 -4780 0 1 {name=l84 lab=[19]}
C {devices/bus_tap.sym} 4380 -4630 0 1 {name=l85 lab=[20]}
C {devices/bus_tap.sym} 4380 -4480 0 1 {name=l86 lab=[21]}
C {devices/bus_tap.sym} 4380 -4330 0 1 {name=l87 lab=[22]}
C {devices/bus_tap.sym} 4380 -4180 0 1 {name=l88 lab=[23]}
C {devices/bus_tap.sym} 4380 -4030 0 1 {name=l89 lab=[24]}
C {devices/bus_tap.sym} 4380 -3880 0 1 {name=l90 lab=[25]}
C {devices/bus_tap.sym} 4380 -3730 0 1 {name=l91 lab=[26]}
C {devices/bus_tap.sym} 4380 -3580 0 1 {name=l92 lab=[27]}
C {devices/bus_tap.sym} 4380 -3430 0 1 {name=l93 lab=[28]}
C {devices/bus_tap.sym} 4380 -3280 0 1 {name=l94 lab=[29]}
C {devices/bus_tap.sym} 4380 -3130 0 1 {name=l95 lab=[30]}
C {devices/bus_tap.sym} 4380 -2980 0 1 {name=l96 lab=[31]}
C {devices/opin.sym} 4380 -7680 1 0 {name=p14 sig_type=std_logic lab=O[31:0]}
C {devices/vsource.sym} 10550 -6460 0 0 {name=VB1 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 10550 -6490 0 0 {name=VB2 sig_type=std_logic lab=A[3]}
C {devices/gnd.sym} 10550 -6430 0 0 {name=l33 lab=GND}
C {devices/vsource.sym} 9990 -6450 0 0 {name=VB3 value="pwl=0 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 9990 -6480 0 0 {name=VB4 sig_type=std_logic lab=A[1]}
C {devices/gnd.sym} 9990 -6420 0 0 {name=l34 lab=GND}
C {devices/vsource.sym} 9780 -6470 0 0 {name=VB5 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 9780 -6500 0 0 {name=VB6 sig_type=std_logic lab=A[0]}
C {devices/gnd.sym} 9780 -6440 0 0 {name=l35 lab=GND}
C {devices/vsource.sym} 10230 -6470 0 0 {name=VB7 value="pwl=0 1.8 100n 1.8 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 10230 -6500 0 0 {name=VB8 sig_type=std_logic lab=A[2]}
C {devices/gnd.sym} 10230 -6440 0 0 {name=l36 lab=GND}
C {devices/vsource.sym} 10550 -6660 0 0 {name=VB9 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 10550 -6690 0 0 {name=VB10 sig_type=std_logic lab=A[7]}
C {devices/gnd.sym} 10550 -6630 0 0 {name=l37 lab=GND}
C {devices/vsource.sym} 9990 -6650 0 0 {name=VB11 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 9990 -6680 0 0 {name=VB12 sig_type=std_logic lab=A[5]}
C {devices/gnd.sym} 9990 -6620 0 0 {name=l38 lab=GND}
C {devices/vsource.sym} 9820 -6670 0 0 {name=VB13 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 9820 -6700 0 0 {name=VB14 sig_type=std_logic lab=A[4]}
C {devices/gnd.sym} 9820 -6640 0 0 {name=l39 lab=GND}
C {devices/vsource.sym} 10230 -6670 0 0 {name=VB15 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 10230 -6700 0 0 {name=VB16 sig_type=std_logic lab=A[6]}
C {devices/gnd.sym} 10230 -6640 0 0 {name=l40 lab=GND}
C {devices/vsource.sym} 10550 -6860 0 0 {name=VB17 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 10550 -6890 0 0 {name=VB18 sig_type=std_logic lab=A[13]}
C {devices/gnd.sym} 10550 -6830 0 0 {name=l41 lab=GND}
C {devices/vsource.sym} 9990 -6850 0 0 {name=VB19 value="pwl=0 1.8 100n 1.8 " savecurrent=false}
C {devices/lab_pin.sym} 9990 -6880 0 0 {name=VB20 sig_type=std_logic lab=A[11]}
C {devices/gnd.sym} 9990 -6820 0 0 {name=l42 lab=GND}
C {devices/vsource.sym} 9820 -6870 0 0 {name=VB21 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 9820 -6900 0 0 {name=VB22 sig_type=std_logic lab=A[10]}
C {devices/gnd.sym} 9820 -6840 0 0 {name=l43 lab=GND}
C {devices/vsource.sym} 10230 -6870 0 0 {name=VB23 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 10230 -6900 0 0 {name=VB24 sig_type=std_logic lab=A[12]}
C {devices/gnd.sym} 10230 -6840 0 0 {name=l44 lab=GND}
C {devices/vsource.sym} 10550 -7060 0 0 {name=VB25 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 10550 -7090 0 0 {name=VB26 sig_type=std_logic lab=A[9]}
C {devices/gnd.sym} 10550 -7030 0 0 {name=l45 lab=GND}
C {devices/vsource.sym} 9990 -7050 0 0 {name=VB27 value="pwl=0 0 100n 0 " savecurrent=false}
C {devices/lab_pin.sym} 9990 -7080 0 0 {name=VB28 sig_type=std_logic lab=A[15]}
C {devices/gnd.sym} 9990 -7020 0 0 {name=l46 lab=GND}
C {devices/vsource.sym} 9820 -7070 0 0 {name=VB29 value="pwl=0 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 9820 -7100 0 0 {name=VB30 sig_type=std_logic lab=A[14]}
C {devices/gnd.sym} 9820 -7040 0 0 {name=l47 lab=GND}
C {devices/vsource.sym} 10230 -7070 0 0 {name=VB31 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 10230 -7100 0 0 {name=VB32 sig_type=std_logic lab=A[8]}
C {devices/gnd.sym} 10230 -7040 0 0 {name=l48 lab=GND}
C {devices/vsource.sym} 10030 -7510 0 0 {name=VA19 value="pwl=0 0 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 10030 -7540 0 0 {name=p22 sig_type=std_logic lab=A[23]}
C {devices/vsource.sym} 10030 -7410 0 0 {name=VA20 value="pwl=0 1.8 50n 1.8 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 10030 -7440 0 0 {name=p23 sig_type=std_logic lab=A[22]}
C {devices/vsource.sym} 10030 -7310 0 0 {name=VA21 value="pwl=0 1.8 50n 1.8 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 10030 -7340 0 0 {name=p24 sig_type=std_logic lab=A[21]}
C {devices/vsource.sym} 10030 -7210 0 0 {name=VA22 value="pwl=0 1.8 50n 1.8 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 10030 -7240 0 0 {name=VA23 sig_type=std_logic lab=A[20]}
C {devices/gnd.sym} 10030 -7180 0 0 {name=l49 lab=GND}
C {devices/gnd.sym} 10030 -7280 0 0 {name=l50 lab=GND}
C {devices/gnd.sym} 10030 -7380 0 0 {name=l51 lab=GND}
C {devices/gnd.sym} 10030 -7480 0 0 {name=l98 lab=GND}
C {devices/vsource.sym} 10450 -7480 0 0 {name=VA24 value="pwl=0 0 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 10450 -7510 0 0 {name=p25 sig_type=std_logic lab=A[17]}
C {devices/vsource.sym} 10450 -7380 0 0 {name=VA25 value="pwl=0 1.8 50n 1.8 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 10450 -7410 0 0 {name=p26 sig_type=std_logic lab=A[16]}
C {devices/gnd.sym} 10450 -7350 0 0 {name=l103 lab=GND}
C {devices/gnd.sym} 10450 -7450 0 0 {name=l106 lab=GND}
C {devices/vsource.sym} 10031.46728515625 -7628.88671875 0 0 {name=VA29 value="pwl=0 1.8 50n 1.8 50n 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 10031.46728515625 -7658.88671875 0 0 {name=p28 sig_type=std_logic lab=A[28]}
C {devices/gnd.sym} 10031.46728515625 -7598.88671875 0 0 {name=l107 lab=GND}
C {devices/vsource.sym} 10451.46728515625 -7608.88671875 0 0 {name=VA30 value="pwl=0 1.8 50n 1.8 50n 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 10451.46728515625 -7638.88671875 0 0 {name=p29 sig_type=std_logic lab=A[18]}
C {devices/gnd.sym} 10451.46728515625 -7578.88671875 0 0 {name=l108 lab=GND}
C {devices/vsource.sym} 10031.46728515625 -7778.88671875 0 0 {name=VA31 value="pwl=0 1.8 50n 1.8 50n 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 10031.46728515625 -7808.88671875 0 0 {name=p30 sig_type=std_logic lab=A[29]}
C {devices/gnd.sym} 10031.46728515625 -7748.88671875 0 0 {name=l109 lab=GND}
C {devices/vsource.sym} 10441.46728515625 -7748.88671875 0 0 {name=VA32 value="pwl=0 1.8 50n 1.8 50n 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 10441.46728515625 -7778.88671875 0 0 {name=p31 sig_type=std_logic lab=A[30]}
C {devices/gnd.sym} 10441.46728515625 -7718.88671875 0 0 {name=l110 lab=GND}
C {devices/vsource.sym} 10221.46728515625 -7288.88671875 0 0 {name=VA38 value="pwl=0 1.8 50n 1.8 50n 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 10221.46728515625 -7318.88671875 0 0 {name=p36 sig_type=std_logic lab=A[19]}
C {devices/gnd.sym} 10221.46728515625 -7258.88671875 0 0 {name=l117 lab=GND}
C {devices/vsource.sym} 10750 -7570 0 0 {name=VA39 value="pwl=0 0 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 10750 -7600 0 0 {name=p37 sig_type=std_logic lab=A[27]}
C {devices/vsource.sym} 10750 -7470 0 0 {name=VA40 value="pwl=0 1.8 50n 1.8 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 10750 -7500 0 0 {name=p38 sig_type=std_logic lab=A[26]}
C {devices/vsource.sym} 10750 -7370 0 0 {name=VA41 value="pwl=0 1.8 50n 1.8 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 10750 -7400 0 0 {name=p39 sig_type=std_logic lab=A[25]}
C {devices/vsource.sym} 10750 -7270 0 0 {name=VA42 value="pwl=0 1.8 50n 1.8 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 10750 -7300 0 0 {name=VA43 sig_type=std_logic lab=A[24]}
C {devices/gnd.sym} 10750 -7240 0 0 {name=l118 lab=GND}
C {devices/gnd.sym} 10750 -7340 0 0 {name=l119 lab=GND}
C {devices/gnd.sym} 10750 -7440 0 0 {name=l120 lab=GND}
C {devices/gnd.sym} 10750 -7540 0 0 {name=l121 lab=GND}
C {devices/vsource.sym} 10711.46728515625 -7668.88671875 0 0 {name=VA44 value="pwl=0 1.8 50n 1.8 50n 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 10711.46728515625 -7698.88671875 0 0 {name=p40 sig_type=std_logic lab=A[31]}
C {devices/gnd.sym} 10711.46728515625 -7638.88671875 0 0 {name=l122 lab=GND}
C {devices/vsource.sym} 11281.46728515625 -6458.88671875 0 0 {name=VDD value=1.8 savecurrent=false}
C {devices/lab_pin.sym} 11281.46728515625 -6488.88671875 0 0 {name=VDD1 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 11281.46728515625 -6428.88671875 0 0 {name=VDD2 lab=GND}
C {devices/code_shown.sym} 11370 -6585 0 0 {name=S1 only_toplevel=false value=".tran 0.01n 300n
.save all"}
C {sky130_fd_pr/corner.sym} 11355 -6515 0 0 {name=CORNER only_toplevel=true corner=tt}
C {devices/vsource.sym} 9120 -6380 0 0 {name=VA17 value="pwl=0 1.8 100n 1.8 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 9120 -6410 0 0 {name=p27 sig_type=std_logic lab=S}
C {devices/vsource.sym} 9120 -6280 0 0 {name=VA18 value="pwl=0 1.8 50n 1.8 50n 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 9120 -6310 0 0 {name=p46 sig_type=std_logic lab=S0}
C {devices/vsource.sym} 9120 -6180 0 0 {name=VA26 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 9120 -6210 0 0 {name=VA27 sig_type=std_logic lab=S1}
C {devices/gnd.sym} 9120 -6150 0 0 {name=l52 lab=GND}
C {devices/gnd.sym} 9120 -6250 0 0 {name=l53 lab=GND}
C {devices/gnd.sym} 9120 -6350 0 0 {name=l54 lab=GND}
C {devices/vsource.sym} 9510 -6180 0 0 {name=VA1 value="pwl=0 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 9510 -6210 0 0 {name=VA2 sig_type=std_logic lab=l}
C {devices/gnd.sym} 9510 -6150 0 0 {name=l55 lab=GND}
C {devices/vsource.sym} 9120 -6070 0 0 {name=VA3 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 9120 -6100 0 0 {name=VA4 sig_type=std_logic lab=S2}
C {devices/gnd.sym} 9120 -6040 0 0 {name=l56 lab=GND}
C {devices/ipin.sym} 3220 -2720 3 0 {name=p10 sig_type=std_logic lab=l}
C {devices/ipin.sym} 3230 -2720 3 0 {name=p18 sig_type=std_logic lab=l}
C {devices/ipin.sym} 3240 -2720 3 0 {name=p19 sig_type=std_logic lab=l}
C {devices/ipin.sym} 3220 -7760 1 0 {name=p20 sig_type=std_logic lab=l}
C {devices/ipin.sym} 3210 -7760 1 0 {name=p21 sig_type=std_logic lab=l}
C {devices/ipin.sym} 3200 -7760 1 0 {name=p32 sig_type=std_logic lab=l}
C {devices/bus_tap.sym} 4270 -7690 0 1 {name=l57 lab=[0]}
C {devices/bus_tap.sym} 4270 -7540 0 1 {name=l58 lab=[1]}
C {devices/bus_tap.sym} 4270 -7390 0 1 {name=l59 lab=[2]}
C {devices/bus_tap.sym} 4270 -7240 0 1 {name=l60 lab=[3]}
C {devices/bus_tap.sym} 4270 -7090 0 1 {name=l61 lab=[4]}
C {devices/bus_tap.sym} 4270 -6940 0 1 {name=l62 lab=[5]}
C {devices/bus_tap.sym} 4270 -6790 0 1 {name=l63 lab=[6]}
C {devices/bus_tap.sym} 4270 -6640 0 1 {name=l64 lab=[7]}
C {devices/bus_tap.sym} 4270 -6490 0 1 {name=l97 lab=[8]}
C {devices/bus_tap.sym} 4270 -6340 0 1 {name=l99 lab=[9]}
C {devices/bus_tap.sym} 4270 -6190 0 1 {name=l100 lab=[10]}
C {devices/bus_tap.sym} 4270 -6040 0 1 {name=l101 lab=[11]}
C {devices/bus_tap.sym} 4270 -5890 0 1 {name=l102 lab=[12]}
C {devices/bus_tap.sym} 4270 -5740 0 1 {name=l104 lab=[13]}
C {devices/bus_tap.sym} 4270 -5590 0 1 {name=l105 lab=[14]}
C {devices/bus_tap.sym} 4270 -5430 0 1 {name=l111 lab=[15]}
C {devices/bus_tap.sym} 4270 -5280 0 1 {name=l112 lab=[16]}
C {devices/bus_tap.sym} 4270 -5130 0 1 {name=l113 lab=[17]}
C {devices/bus_tap.sym} 4270 -4980 0 1 {name=l114 lab=[18]}
C {devices/bus_tap.sym} 4270 -4830 0 1 {name=l115 lab=[19]}
C {devices/bus_tap.sym} 4270 -4680 0 1 {name=l116 lab=[20]}
C {devices/bus_tap.sym} 4270 -4530 0 1 {name=l123 lab=[21]}
C {devices/bus_tap.sym} 4270 -4380 0 1 {name=l124 lab=[22]}
C {devices/bus_tap.sym} 4270 -4230 0 1 {name=l125 lab=[23]}
C {devices/bus_tap.sym} 4270 -4080 0 1 {name=l126 lab=[24]}
C {devices/bus_tap.sym} 4270 -3930 0 1 {name=l127 lab=[25]}
C {devices/bus_tap.sym} 4270 -3780 0 1 {name=l128 lab=[26]}
C {devices/bus_tap.sym} 4270 -3630 0 1 {name=l129 lab=[27]}
C {devices/bus_tap.sym} 4270 -3480 0 1 {name=l130 lab=[28]}
C {devices/bus_tap.sym} 4270 -3330 0 1 {name=l131 lab=[29]}
C {devices/bus_tap.sym} 4270 -3180 0 1 {name=l132 lab=[30]}
C {devices/bus_tap.sym} 4270 -3030 0 1 {name=l133 lab=[31]}
C {devices/opin.sym} 4270 -7730 1 0 {name=p1 sig_type=std_logic lab=n[31:0]}
C {4x1_mux.sym} 2300 -7680 0 0 {name=x1}
C {4x1_mux.sym} 2300 -7530 0 0 {name=x2}
C {4x1_mux.sym} 2300 -7380 0 0 {name=x3}
C {4x1_mux.sym} 2300 -7230 0 0 {name=x4}
C {4x1_mux.sym} 2300 -7080 0 0 {name=x5}
C {4x1_mux.sym} 2300 -6930 0 0 {name=x6}
C {4x1_mux.sym} 2300 -6780 0 0 {name=x7}
C {4x1_mux.sym} 2300 -6630 0 0 {name=x8}
C {4x1_mux.sym} 2300 -6480 0 0 {name=x9}
C {4x1_mux.sym} 2300 -6330 0 0 {name=x10}
C {4x1_mux.sym} 2300 -6180 0 0 {name=x11}
C {4x1_mux.sym} 2300 -6030 0 0 {name=x12}
C {4x1_mux.sym} 2300 -5880 0 0 {name=x13}
C {4x1_mux.sym} 2300 -5730 0 0 {name=x14}
C {4x1_mux.sym} 2300 -5580 0 0 {name=x15}
C {4x1_mux.sym} 2300 -5420 0 0 {name=x16}
C {4x1_mux.sym} 2300 -5270 0 0 {name=x17}
C {4x1_mux.sym} 2300 -5120 0 0 {name=x18}
C {4x1_mux.sym} 2300 -4970 0 0 {name=x19}
C {4x1_mux.sym} 2300 -4820 0 0 {name=x20}
C {4x1_mux.sym} 2300 -4670 0 0 {name=x21}
C {4x1_mux.sym} 2300 -4520 0 0 {name=x22}
C {4x1_mux.sym} 2300 -4370 0 0 {name=x23}
C {4x1_mux.sym} 2300 -4220 0 0 {name=x24}
C {4x1_mux.sym} 2300 -4070 0 0 {name=x25}
C {4x1_mux.sym} 2300 -3920 0 0 {name=x26}
C {4x1_mux.sym} 2300 -3770 0 0 {name=x27}
C {4x1_mux.sym} 2300 -3620 0 0 {name=x28}
C {4x1_mux.sym} 2300 -3470 0 0 {name=x29}
C {4x1_mux.sym} 2300 -3320 0 0 {name=x30}
C {devices/bus_tap.sym} 1320 -7790 1 0 {name=l1 lab=[0]}
C {devices/bus_tap.sym} 1280 -7790 1 0 {name=l2 lab=[1]}
C {devices/bus_tap.sym} 1240 -7790 1 0 {name=l3 lab=[2]}
C {devices/bus_tap.sym} 1200 -7790 1 0 {name=l4 lab=[3]}
C {devices/bus_tap.sym} 1160 -7790 1 0 {name=l5 lab=[4]}
C {devices/bus_tap.sym} 1120 -7790 1 0 {name=l6 lab=[5]}
C {devices/bus_tap.sym} 1080 -7790 1 0 {name=l7 lab=[6]}
C {devices/bus_tap.sym} 1040 -7790 1 0 {name=l8 lab=[7]}
C {devices/bus_tap.sym} 1000 -7790 1 0 {name=l9 lab=[8]}
C {devices/bus_tap.sym} 960 -7790 1 0 {name=l10 lab=[9]}
C {devices/bus_tap.sym} 920 -7790 1 0 {name=l11 lab=[10]}
C {devices/bus_tap.sym} 880 -7790 1 0 {name=l12 lab=[11]}
C {devices/bus_tap.sym} 840 -7790 1 0 {name=l13 lab=[12]}
C {devices/bus_tap.sym} 800 -7790 1 0 {name=l14 lab=[13]}
C {devices/bus_tap.sym} 760 -7790 1 0 {name=l15 lab=[14]}
C {devices/bus_tap.sym} 720 -7790 1 0 {name=l16 lab=[15]}
C {devices/bus_tap.sym} 680 -7790 1 0 {name=l17 lab=[16]}
C {devices/bus_tap.sym} 640 -7790 1 0 {name=l18 lab=[17]}
C {devices/bus_tap.sym} 600 -7790 1 0 {name=l19 lab=[18]}
C {devices/bus_tap.sym} 560 -7790 1 0 {name=l20 lab=[19]}
C {devices/bus_tap.sym} 520 -7790 1 0 {name=l21 lab=[20]}
C {devices/bus_tap.sym} 480 -7790 1 0 {name=l23 lab=[21]}
C {devices/bus_tap.sym} 440 -7790 1 0 {name=l24 lab=[22]}
C {devices/bus_tap.sym} 400 -7790 1 0 {name=l25 lab=[23]}
C {devices/bus_tap.sym} 360 -7790 1 0 {name=l26 lab=[24]}
C {devices/bus_tap.sym} 320 -7790 1 0 {name=l27 lab=[25]}
C {devices/bus_tap.sym} 280 -7790 1 0 {name=l28 lab=[26]}
C {devices/bus_tap.sym} 240 -7790 1 0 {name=l29 lab=[27]}
C {devices/bus_tap.sym} 200 -7790 1 0 {name=l30 lab=[28]}
C {devices/bus_tap.sym} 160 -7790 1 0 {name=l31 lab=[29]}
C {devices/bus_tap.sym} 110 -7790 1 0 {name=l22 lab=[30]}
C {devices/bus_tap.sym} 70 -7790 1 0 {name=l32 lab=[31]}
C {4x1_mux.sym} 2300 -3170 0 0 {name=x31}
C {4x1_mux.sym} 2300 -3020 0 0 {name=x32}
C {2x1_mux.sym} 1850 -7630 0 0 {name=x67}
C {2x1_mux.sym} 1850 -7490 0 0 {name=x68}
C {2x1_mux.sym} 1850 -7340 0 0 {name=x69}
C {2x1_mux.sym} 1850 -7190 0 0 {name=x70}
C {2x1_mux.sym} 1850 -7050 0 0 {name=x71}
C {2x1_mux.sym} 1850 -6880 0 0 {name=x72}
C {2x1_mux.sym} 1850 -6730 0 0 {name=x73}
C {2x1_mux.sym} 1850 -6580 0 0 {name=x74}
C {2x1_mux.sym} 1850 -6430 0 0 {name=x75}
C {2x1_mux.sym} 1850 -6280 0 0 {name=x76}
C {2x1_mux.sym} 1850 -6140 0 0 {name=x77}
C {2x1_mux.sym} 1850 -5980 0 0 {name=x78}
C {2x1_mux.sym} 1850 -5840 0 0 {name=x79}
C {2x1_mux.sym} 1850 -5690 0 0 {name=x80}
C {2x1_mux.sym} 1850 -5530 0 0 {name=x81}
C {2x1_mux.sym} 1850 -5370 0 0 {name=x82}
C {2x1_mux.sym} 1850 -5220 0 0 {name=x83}
C {2x1_mux.sym} 1850 -5070 0 0 {name=x84}
C {2x1_mux.sym} 1850 -4920 0 0 {name=x85}
C {2x1_mux.sym} 1850 -4770 0 0 {name=x86}
C {2x1_mux.sym} 1850 -4620 0 0 {name=x87}
C {2x1_mux.sym} 1850 -4470 0 0 {name=x88}
C {2x1_mux.sym} 1850 -4320 0 0 {name=x89}
C {2x1_mux.sym} 1850 -4170 0 0 {name=x90}
C {2x1_mux.sym} 1850 -4020 0 0 {name=x91}
C {2x1_mux.sym} 1850 -3860 0 0 {name=x92}
C {2x1_mux.sym} 1850 -3720 0 0 {name=x93}
C {2x1_mux.sym} 1850 -3580 0 0 {name=x94}
C {2x1_mux.sym} 1850 -3420 0 0 {name=x95}
C {2x1_mux.sym} 1850 -3270 0 0 {name=x96}
C {2x1_mux.sym} 1850 -3120 0 0 {name=x97}
C {2x1_mux.sym} 1850 -2980 0 0 {name=x98}
C {devices/ipin.sym} 70 -7790 0 0 {name=p16 sig_type=std_logic lab=A[31:0]}
C {devices/ipin.sym} 2180 -7800 1 0 {name=p2 sig_type=std_logic lab=S0}
C {devices/ipin.sym} 2130 -7800 1 0 {name=p8 sig_type=std_logic lab=S1}
C {devices/ipin.sym} 1750 -7750 1 0 {name=p17 sig_type=std_logic lab=S}
C {devices/ipin.sym} 1770 -7740 1 0 {name=p3 sig_type=std_logic lab=l}
C {devices/ipin.sym} 1710 -2760 1 0 {name=p4 sig_type=std_logic lab=l}
C {devices/ipin.sym} 2110 -2910 1 0 {name=p5 sig_type=std_logic lab=l}
C {2x1_mux.sym} 2680 -7630 0 0 {name=x33}
C {2x1_mux.sym} 2680 -7490 0 0 {name=x34}
C {2x1_mux.sym} 2680 -7340 0 0 {name=x35}
C {2x1_mux.sym} 2680 -7190 0 0 {name=x36}
C {2x1_mux.sym} 2680 -7050 0 0 {name=x37}
C {2x1_mux.sym} 2680 -6880 0 0 {name=x38}
C {2x1_mux.sym} 2680 -6730 0 0 {name=x39}
C {2x1_mux.sym} 2680 -6580 0 0 {name=x40}
C {2x1_mux.sym} 2680 -6430 0 0 {name=x41}
C {2x1_mux.sym} 2680 -6280 0 0 {name=x42}
C {2x1_mux.sym} 2680 -6140 0 0 {name=x43}
C {2x1_mux.sym} 2680 -5980 0 0 {name=x44}
C {2x1_mux.sym} 2680 -5840 0 0 {name=x45}
C {2x1_mux.sym} 2680 -5690 0 0 {name=x46}
C {2x1_mux.sym} 2680 -5530 0 0 {name=x47}
C {2x1_mux.sym} 2680 -5370 0 0 {name=x48}
C {2x1_mux.sym} 2680 -5220 0 0 {name=x49}
C {2x1_mux.sym} 2680 -5070 0 0 {name=x50}
C {2x1_mux.sym} 2680 -4920 0 0 {name=x51}
C {2x1_mux.sym} 2680 -4770 0 0 {name=x52}
C {2x1_mux.sym} 2680 -4620 0 0 {name=x53}
C {2x1_mux.sym} 2680 -4470 0 0 {name=x54}
C {2x1_mux.sym} 2680 -4320 0 0 {name=x55}
C {2x1_mux.sym} 2680 -4170 0 0 {name=x56}
C {2x1_mux.sym} 2680 -4020 0 0 {name=x57}
C {2x1_mux.sym} 2680 -3860 0 0 {name=x58}
C {2x1_mux.sym} 2680 -3720 0 0 {name=x59}
C {2x1_mux.sym} 2680 -3580 0 0 {name=x60}
C {2x1_mux.sym} 2680 -3420 0 0 {name=x61}
C {2x1_mux.sym} 2680 -3270 0 0 {name=x62}
C {2x1_mux.sym} 2680 -3120 0 0 {name=x63}
C {2x1_mux.sym} 2680 -2980 0 0 {name=x64}
C {devices/ipin.sym} 2580 -7800 1 0 {name=p11 sig_type=std_logic lab=S}
C {devices/ipin.sym} 2600 -7810 1 0 {name=p12 sig_type=std_logic lab=l}
C {devices/ipin.sym} 2540 -2760 3 0 {name=p13 sig_type=std_logic lab=l}
