v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
B 2 4560 -8190 5360 -7790 {flags=graph
y1=0
y2=2
ypos1=-0.1
ypos2=1.9
divy=5
subdivy=1
unity=1
x1=2.5e-08
x2=1.25e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
digital=1

color="10 10 10 10 4 4"
node="sel;s0,s1,s2
s
a;a[31],a[30],a[29],a[28],a[27],a[26],a[25],a[24],a[23],a[22],a[21],a[20],a[19],a[18],a[17],a[16],a[15],a[14],a[13],a[12],a[11],a[10],a[9],a[8],a[7],a[6],a[5],a[4],a[3],a[2],a[1],a[0]
o;o[31],o[30],o[29],o[28],o[27],o[26],o[25],o[24],o[23],o[22],o[21],o[20],o[19],o[18],o[17],o[16],o[15],o[14],o[13],o[12],o[11],o[10],o[9],o[8],o[7],o[6],o[5],o[4],o[3],o[2],o[1],o[0]
ssel;s0,s1
stg1;net31,net30,net29,net28,net27,net26,net25,net24,net23,net22,net21,net20,net19,net18,net17,net16,net15,net14,net13,net12,net11,net10,net9,net8,net7,net64,net6,net5,net4,net3,net2,net1"
rainbow=1}
B 2 4560 -7770 5360 -7370 {flags=graph
y1=0
y2=2
ypos1=10.6
ypos2=12.6
divy=5
subdivy=1
unity=1
x1=2.5e-08
x2=1.25e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
digital=1

color="11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 11 17 18 19 20 21 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 7 8 9"
node="o[31]
o[30]
o[29]
o[28]
o[27]
o[26]
o[25]
o[24]
o[23]
o[22]
o[21]
o[20]
o[19]
o[18]
o[17]
o[16]
o[15]
o[14]
o[13]
o[12]
o[11]
o[10]
o[9]
o[8]
o[7]
o[6]
o[5]
o[4]
o[3]
o[2]
o[1]
o[0]
s
l
net1
net2
net3
net4
net5
net6
net7
net8
net9
net10
net11
net12
net13
net14
net15
net16
net17
net18
net19
net20
net21
net22
net23
net24
net25
net64
net65
net66
net67
net75
net76
net77
net78
net79
net80
net81
net82
net83
net84
net85
net86
net87
net88
net89
net90
net91
net92
net93
net94
net95
net96
"
rainbow=1}
B 2 4560 -8620 5360 -8220 {flags=graph
y1=0
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.5e-08
x2=1.25e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
digital=1

color="11 11"
node="net8
net91"
rainbow=1}
T {number bit shift by mux
s0 0 0 1 1
s1 0 1 0 1
O  0 1 2 3 bit shift
} 610 -9000 0 0 1 1 {}
T {Shift type
S 0 1
O L R} 1570 -9000 0 0 1 1 {}
N 2850 -7760 2850 -5450 {
lab=S0}
N 2850 -7720 2900 -7720 {
lab=S0}
N 2800 -7700 2900 -7700 {
lab=S1}
N 2850 -7570 2900 -7570 {
lab=S0}
N 2800 -7550 2900 -7550 {
lab=S1}
N 2850 -7420 2900 -7420 {
lab=S0}
N 2800 -7400 2900 -7400 {
lab=S1}
N 2850 -7270 2900 -7270 {
lab=S0}
N 2800 -7250 2900 -7250 {
lab=S1}
N 2850 -7120 2900 -7120 {
lab=S0}
N 2800 -7100 2900 -7100 {
lab=S1}
N 2850 -6970 2900 -6970 {
lab=S0}
N 2800 -6950 2900 -6950 {
lab=S1}
N 2850 -6820 2900 -6820 {
lab=S0}
N 2800 -6800 2900 -6800 {
lab=S1}
N 2850 -6670 2900 -6670 {
lab=S0}
N 2800 -6650 2900 -6650 {
lab=S1}
N 2850 -6520 2900 -6520 {
lab=S0}
N 2800 -6500 2900 -6500 {
lab=S1}
N 2850 -6370 2900 -6370 {
lab=S0}
N 2800 -6350 2900 -6350 {
lab=S1}
N 2850 -6220 2900 -6220 {
lab=S0}
N 2800 -6200 2900 -6200 {
lab=S1}
N 2850 -6070 2900 -6070 {
lab=S0}
N 2800 -6050 2900 -6050 {
lab=S1}
N 2850 -5920 2900 -5920 {
lab=S0}
N 2800 -5900 2900 -5900 {
lab=S1}
N 2850 -5770 2900 -5770 {
lab=S0}
N 2800 -5750 2900 -5750 {
lab=S1}
N 2850 -5620 2900 -5620 {
lab=S0}
N 2800 -5600 2900 -5600 {
lab=S1}
N 2850 -5500 2850 -3190 {
lab=S0}
N 2850 -5460 2900 -5460 {
lab=S0}
N 2800 -5440 2900 -5440 {
lab=S1}
N 2850 -5310 2900 -5310 {
lab=S0}
N 2800 -5290 2900 -5290 {
lab=S1}
N 2850 -5160 2900 -5160 {
lab=S0}
N 2800 -5140 2900 -5140 {
lab=S1}
N 2850 -5010 2900 -5010 {
lab=S0}
N 2800 -4990 2900 -4990 {
lab=S1}
N 2850 -4860 2900 -4860 {
lab=S0}
N 2800 -4840 2900 -4840 {
lab=S1}
N 2850 -4710 2900 -4710 {
lab=S0}
N 2800 -4690 2900 -4690 {
lab=S1}
N 2850 -4560 2900 -4560 {
lab=S0}
N 2800 -4540 2900 -4540 {
lab=S1}
N 2850 -4410 2900 -4410 {
lab=S0}
N 2800 -4390 2900 -4390 {
lab=S1}
N 2850 -4260 2900 -4260 {
lab=S0}
N 2800 -4240 2900 -4240 {
lab=S1}
N 2850 -4110 2900 -4110 {
lab=S0}
N 2800 -4090 2900 -4090 {
lab=S1}
N 2850 -3960 2900 -3960 {
lab=S0}
N 2800 -3940 2900 -3940 {
lab=S1}
N 2850 -3810 2900 -3810 {
lab=S0}
N 2800 -3790 2900 -3790 {
lab=S1}
N 2850 -3660 2900 -3660 {
lab=S0}
N 2800 -3640 2900 -3640 {
lab=S1}
N 2850 -3510 2900 -3510 {
lab=S0}
N 2800 -3490 2900 -3490 {
lab=S1}
N 2850 -3360 2900 -3360 {
lab=S0}
N 2800 -3340 2900 -3340 {
lab=S1}
N 2000 -7740 2000 -3180 {
lab=A[0]}
N 1920 -7740 1920 -3180 {
lab=A[2]}
N 1840 -7740 1840 -3180 {
lab=A[4]}
N 1760 -7740 1760 -3180 {
lab=A[6]}
N 1680 -7740 1680 -3180 {
lab=A[8]}
N 1600 -7740 1600 -3180 {
lab=A[10]}
N 1520 -7740 1520 -3180 {
lab=A[12]}
N 1440 -7740 1440 -3180 {
lab=A[14]}
N 1360 -7740 1360 -3180 {
lab=A[16]}
N 1280 -7740 1280 -3180 {
lab=A[18]}
N 1200 -7740 1200 -3180 {
lab=A[20]}
N 1120 -7740 1120 -3180 {
lab=A[22]}
N 1040 -7740 1040 -3180 {
lab=A[24]}
N 960 -7740 960 -3180 {
lab=A[26]}
N 880 -7740 880 -3180 {
lab=A[28]}
N 790 -7740 790 -3180 {
lab=A[30]}
N 1320 -7740 1320 -3180 {
lab=A[17]}
N 1240 -7740 1240 -3180 {
lab=A[19]}
N 1160 -7740 1160 -3180 {
lab=A[21]}
N 1080 -7740 1080 -3180 {
lab=A[23]}
N 1000 -7740 1000 -3180 {
lab=A[25]}
N 920 -7740 920 -3180 {
lab=A[27]}
N 840 -7740 840 -3180 {
lab=A[29]}
N 750 -7740 750 -3180 {
lab=A[31]}
N 1400 -7740 1400 -3180 {
lab=A[15]}
N 1480 -7740 1480 -3180 {
lab=A[13]}
N 1560 -7740 1560 -3180 {
lab=A[11]}
N 1640 -7740 1640 -3180 {
lab=A[9]}
N 1720 -7740 1720 -3180 {
lab=A[7]}
N 1800 -7740 1800 -3180 {
lab=A[5]}
N 1880 -7740 1880 -3180 {
lab=A[3]}
N 1960 -7740 1960 -3180 {
lab=A[1]}
N 1920 -7150 2310 -7150 {
lab=A[2]}
N 1880 -7010 2310 -7010 {
lab=A[3]}
N 2850 -3210 2900 -3210 {
lab=S0}
N 2850 -3060 2900 -3060 {
lab=S0}
N 2800 -3040 2900 -3040 {
lab=S1}
N 2800 -3200 2800 -3040 {
lab=S1}
N 2850 -3190 2850 -3060 {
lab=S0}
N 1960 -7570 2310 -7570 {
lab=A[1]}
N 1960 -7300 2350 -7300 {
lab=A[1]}
N 1840 -6840 2310 -6840 {
lab=A[4]}
N 2000 -7450 2390 -7450 {
lab=A[0]}
N 1800 -6990 2310 -6990 {
lab=A[5]}
N 1920 -7430 2350 -7430 {
lab=A[2]}
N 1880 -7280 2350 -7280 {
lab=A[3]}
N 1840 -7130 2350 -7130 {
lab=A[4]}
N 1760 -6820 2310 -6820 {
lab=A[6]}
N 740 -7750 2010 -7750 {
bus=true lab=A[31:0]}
N 3030 -7700 3090 -7700 {
lab=#net1}
N 3030 -7550 3090 -7550 {
lab=#net2}
N 3030 -7400 3090 -7400 {
lab=#net3}
N 3030 -7250 3090 -7250 {
lab=#net4}
N 3030 -7100 3090 -7100 {
lab=#net5}
N 3030 -6950 3090 -6950 {
lab=#net6}
N 3030 -6650 3090 -6650 {
lab=#net7}
N 3030 -6500 3090 -6500 {
lab=#net8}
N 3030 -6350 3090 -6350 {
lab=#net9}
N 3030 -6200 3090 -6200 {
lab=#net10}
N 3030 -6050 3090 -6050 {
lab=#net11}
N 3030 -5900 3090 -5900 {
lab=#net12}
N 3030 -5750 3090 -5750 {
lab=#net13}
N 3030 -5600 3090 -5600 {
lab=#net14}
N 3030 -5440 3090 -5440 {
lab=#net15}
N 3030 -5290 3090 -5290 {
lab=#net16}
N 3030 -5140 3090 -5140 {
lab=#net17}
N 3030 -4990 3090 -4990 {
lab=#net18}
N 3030 -4840 3090 -4840 {
lab=#net19}
N 3030 -4690 3090 -4690 {
lab=#net20}
N 3030 -4540 3090 -4540 {
lab=#net21}
N 3030 -4390 3090 -4390 {
lab=#net22}
N 3030 -4240 3090 -4240 {
lab=#net23}
N 3030 -4090 3090 -4090 {
lab=#net24}
N 3030 -3940 3090 -3940 {
lab=#net25}
N 3030 -3790 3090 -3790 {
lab=#net26}
N 3030 -3640 3090 -3640 {
lab=#net27}
N 3030 -3490 3090 -3490 {
lab=#net28}
N 3030 -3340 3090 -3340 {
lab=#net29}
N 3030 -3190 3090 -3190 {
lab=#net30}
N 3030 -3040 3090 -3040 {
lab=#net31}
N 2310 -7570 2460 -7570 {
lab=A[1]}
N 2390 -7450 2460 -7450 {
lab=A[0]}
N 2350 -7430 2460 -7430 {
lab=A[2]}
N 2350 -7300 2460 -7300 {
lab=A[1]}
N 2350 -7280 2460 -7280 {
lab=A[3]}
N 2350 -7130 2460 -7130 {
lab=A[4]}
N 2310 -7150 2460 -7150 {
lab=A[2]}
N 2310 -7010 2460 -7010 {
lab=A[3]}
N 2310 -6840 2460 -6840 {
lab=A[4]}
N 1800 -6690 2460 -6690 {
lab=A[5]}
N 1760 -6540 2460 -6540 {
lab=A[6]}
N 1720 -6390 2460 -6390 {
lab=A[7]}
N 1680 -6240 2460 -6240 {
lab=A[8]}
N 1640 -6100 2460 -6100 {
lab=A[9]}
N 1600 -5940 2460 -5940 {
lab=A[10]}
N 1560 -5800 2460 -5800 {
lab=A[11]}
N 1520 -5650 2460 -5650 {
lab=A[12]}
N 1480 -5490 2460 -5490 {
lab=A[13]}
N 1440 -5330 2460 -5330 {
lab=A[14]}
N 1400 -5180 2460 -5180 {
lab=A[15]}
N 1360 -5030 2460 -5030 {
lab=A[16]}
N 1320 -4880 2460 -4880 {
lab=A[17]}
N 1280 -4730 2460 -4730 {
lab=A[18]}
N 1240 -4580 2460 -4580 {
lab=A[19]}
N 1200 -4430 2460 -4430 {
lab=A[20]}
N 1160 -4280 2460 -4280 {
lab=A[21]}
N 1120 -4130 2460 -4130 {
lab=A[22]}
N 1080 -3980 2460 -3980 {
lab=A[23]}
N 1040 -3820 2460 -3820 {
lab=A[24]}
N 1000 -3680 2460 -3680 {
lab=A[25]}
N 960 -3540 2460 -3540 {
lab=A[26]}
N 920 -3380 2460 -3380 {
lab=A[27]}
N 880 -3230 2460 -3230 {
lab=A[28]}
N 840 -3080 2460 -3080 {
lab=A[29]}
N 790 -2940 2460 -2940 {
lab=A[30]}
N 2310 -6990 2460 -6990 {
lab=A[5]}
N 2310 -6820 2450 -6820 {
lab=A[6]}
N 2450 -6820 2460 -6820 {
lab=A[6]}
N 1720 -6670 2380 -6670 {
lab=A[7]}
N 1680 -6520 2380 -6520 {
lab=A[8]}
N 1640 -6370 2380 -6370 {
lab=A[9]}
N 1600 -6220 2380 -6220 {
lab=A[10]}
N 1560 -6080 2380 -6080 {
lab=A[11]}
N 1520 -5920 2380 -5920 {
lab=A[12]}
N 1480 -5780 2380 -5780 {
lab=A[13]}
N 1440 -5630 2380 -5630 {
lab=A[14]}
N 1400 -5470 2380 -5470 {
lab=A[15]}
N 1360 -5310 2380 -5310 {
lab=A[16]}
N 1320 -5160 2380 -5160 {
lab=A[17]}
N 1280 -5010 2380 -5010 {
lab=A[18]}
N 1240 -4860 2380 -4860 {
lab=A[19]}
N 1200 -4710 2380 -4710 {
lab=A[20]}
N 1160 -4560 2380 -4560 {
lab=A[21]}
N 1120 -4410 2380 -4410 {
lab=A[22]}
N 1080 -4260 2380 -4260 {
lab=A[23]}
N 1040 -4110 2380 -4110 {
lab=A[24]}
N 1000 -3960 2380 -3960 {
lab=A[25]}
N 960 -3800 2380 -3800 {
lab=A[26]}
N 920 -3660 2380 -3660 {
lab=A[27]}
N 880 -3520 2380 -3520 {
lab=A[28]}
N 840 -3360 2380 -3360 {
lab=A[29]}
N 800 -3210 2380 -3210 {
lab=A[30]}
N 760 -3060 2380 -3060 {
lab=A[31]}
N 2380 -6670 2460 -6670 {
lab=A[7]}
N 2380 -6520 2460 -6520 {
lab=A[8]}
N 2380 -6370 2460 -6370 {
lab=A[9]}
N 2380 -6220 2460 -6220 {
lab=A[10]}
N 2380 -6080 2460 -6080 {
lab=A[11]}
N 2380 -5920 2460 -5920 {
lab=A[12]}
N 2380 -5780 2460 -5780 {
lab=A[13]}
N 2380 -5630 2460 -5630 {
lab=A[14]}
N 2380 -5470 2460 -5470 {
lab=A[15]}
N 2380 -5310 2460 -5310 {
lab=A[16]}
N 2380 -5160 2460 -5160 {
lab=A[17]}
N 2380 -5010 2460 -5010 {
lab=A[18]}
N 2380 -4860 2460 -4860 {
lab=A[19]}
N 2380 -4710 2460 -4710 {
lab=A[20]}
N 2380 -4560 2460 -4560 {
lab=A[21]}
N 2380 -4410 2460 -4410 {
lab=A[22]}
N 2380 -4260 2460 -4260 {
lab=A[23]}
N 2380 -4110 2460 -4110 {
lab=A[24]}
N 2380 -3960 2460 -3960 {
lab=A[25]}
N 2380 -3800 2460 -3800 {
lab=A[26]}
N 2380 -3660 2460 -3660 {
lab=A[27]}
N 2380 -3520 2460 -3520 {
lab=A[28]}
N 2380 -2920 2460 -2920 {
lab=l}
N 2380 -3060 2460 -3060 {
lab=A[31]}
N 2380 -3210 2460 -3210 {
lab=A[30]}
N 2380 -3360 2460 -3360 {
lab=A[29]}
N 750 -4390 760 -4390 {
lab=A[31]}
N 790 -4490 800 -4490 {
lab=A[30]}
N 2000 -7670 2900 -7670 {
lab=A[0]}
N 1960 -7520 2900 -7520 {
lab=A[1]}
N 1920 -7370 2900 -7370 {
lab=A[2]}
N 1880 -7220 2900 -7220 {
lab=A[3]}
N 1840 -7070 2900 -7070 {
lab=A[4]}
N 1800 -6920 2900 -6920 {
lab=A[5]}
N 750 -3180 750 -2840 {
lab=A[31]}
N 790 -3180 790 -2840 {
lab=A[30]}
N 840 -3180 840 -2840 {
lab=A[29]}
N 880 -3180 880 -2840 {
lab=A[28]}
N 920 -3180 920 -2840 {
lab=A[27]}
N 960 -3180 960 -2840 {
lab=A[26]}
N 1000 -3180 1000 -2840 {
lab=A[25]}
N 1040 -3180 1040 -2840 {
lab=A[24]}
N 1080 -3180 1080 -2840 {
lab=A[23]}
N 1120 -3180 1120 -2840 {
lab=A[22]}
N 1160 -3180 1160 -2840 {
lab=A[21]}
N 1200 -3180 1200 -2840 {
lab=A[20]}
N 1240 -3180 1240 -2840 {
lab=A[19]}
N 1280 -3180 1280 -2840 {
lab=A[18]}
N 1320 -3180 1320 -2840 {
lab=A[17]}
N 1360 -3180 1360 -2840 {
lab=A[16]}
N 1400 -3180 1400 -2840 {
lab=A[15]}
N 1440 -3180 1440 -2840 {
lab=A[14]}
N 1480 -3180 1480 -2840 {
lab=A[13]}
N 1520 -3180 1520 -2840 {
lab=A[12]}
N 1560 -3180 1560 -2840 {
lab=A[11]}
N 1600 -3180 1600 -2840 {
lab=A[10]}
N 1640 -3180 1640 -2840 {
lab=A[9]}
N 1680 -3180 1680 -2840 {
lab=A[8]}
N 1720 -3180 1720 -2840 {
lab=A[7]}
N 1760 -3180 1760 -2840 {
lab=A[6]}
N 1800 -3180 1800 -2840 {
lab=A[5]}
N 1840 -3180 1840 -2840 {
lab=A[4]}
N 1880 -3180 1880 -2840 {
lab=A[3]}
N 1920 -3180 1920 -2840 {
lab=A[2]}
N 1960 -3180 1960 -2840 {
lab=A[1]}
N 2000 -3180 2000 -2840 {
lab=A[0]}
N 750 -3010 2900 -3010 {
lab=A[31]}
N 790 -3160 2900 -3160 {
lab=A[30]}
N 840 -3310 2900 -3310 {
lab=A[29]}
N 880 -3460 2900 -3460 {
lab=A[28]}
N 920 -3610 2900 -3610 {
lab=A[27]}
N 960 -3760 2900 -3760 {
lab=A[26]}
N 1010 -3910 2900 -3910 {
lab=A[25]}
N 1000 -3910 1010 -3910 {
lab=A[25]}
N 1040 -4060 2900 -4060 {
lab=A[24]}
N 1080 -4210 2900 -4210 {
lab=A[23]}
N 1120 -4360 2900 -4360 {
lab=A[22]}
N 1160 -4510 2900 -4510 {
lab=A[21]}
N 1200 -4660 2900 -4660 {
lab=A[20]}
N 1280 -4960 2900 -4960 {
lab=A[18]}
N 1240 -4810 2900 -4810 {
lab=A[19]}
N 1320 -5110 2900 -5110 {
lab=A[17]}
N 1360 -5260 2900 -5260 {
lab=A[16]}
N 1400 -5410 2900 -5410 {
lab=A[15]}
N 1440 -5570 2900 -5570 {
lab=A[14]}
N 1480 -5720 2900 -5720 {
lab=A[13]}
N 1530 -5870 2900 -5870 {
lab=A[12]}
N 1520 -5870 1530 -5870 {
lab=A[12]}
N 1560 -6020 2900 -6020 {
lab=A[11]}
N 1600 -6170 2900 -6170 {
lab=A[10]}
N 1640 -6320 2900 -6320 {
lab=A[9]}
N 1680 -6470 2900 -6470 {
lab=A[8]}
N 1720 -6620 2900 -6620 {
lab=A[7]}
N 1760 -6770 2900 -6770 {
lab=A[6]}
N 2590 -7650 2590 -7620 {
lab=#net32}
N 2590 -7650 2900 -7650 {
lab=#net32}
N 2590 -7500 2590 -7480 {
lab=#net33}
N 2590 -7500 2900 -7500 {
lab=#net33}
N 2590 -7350 2590 -7330 {
lab=#net34}
N 2590 -7350 2900 -7350 {
lab=#net34}
N 2590 -7200 2900 -7200 {
lab=#net35}
N 2590 -7050 2900 -7050 {
lab=#net36}
N 2590 -6900 2900 -6900 {
lab=#net37}
N 2590 -6750 2900 -6750 {
lab=#net38}
N 2590 -6600 2900 -6600 {
lab=#net39}
N 2590 -6450 2900 -6450 {
lab=#net40}
N 2590 -6300 2900 -6300 {
lab=#net41}
N 2590 -6150 2900 -6150 {
lab=#net42}
N 2590 -6000 2900 -6000 {
lab=#net43}
N 2590 -5850 2900 -5850 {
lab=#net44}
N 2590 -5700 2900 -5700 {
lab=#net45}
N 2590 -5550 2900 -5550 {
lab=#net46}
N 2590 -5390 2900 -5390 {
lab=#net47}
N 2590 -5240 2900 -5240 {
lab=#net48}
N 2590 -5090 2900 -5090 {
lab=#net49}
N 2590 -4940 2900 -4940 {
lab=#net50}
N 2590 -4790 2900 -4790 {
lab=#net51}
N 2590 -4640 2900 -4640 {
lab=#net52}
N 2590 -4490 2900 -4490 {
lab=#net53}
N 2590 -4340 2900 -4340 {
lab=#net54}
N 2590 -4190 2900 -4190 {
lab=#net55}
N 2590 -4040 2900 -4040 {
lab=#net56}
N 2590 -3890 2900 -3890 {
lab=#net57}
N 2590 -3740 2900 -3740 {
lab=#net58}
N 2590 -3590 2900 -3590 {
lab=#net59}
N 2590 -3440 2900 -3440 {
lab=#net60}
N 2590 -3290 2900 -3290 {
lab=#net61}
N 2590 -3140 2900 -3140 {
lab=#net62}
N 2590 -2990 2900 -2990 {
lab=#net63}
N 2590 -2990 2590 -2970 {
lab=#net63}
N 2590 -3140 2590 -3110 {
lab=#net62}
N 2590 -3290 2590 -3260 {
lab=#net61}
N 2590 -3440 2590 -3410 {
lab=#net60}
N 2590 -3590 2590 -3570 {
lab=#net59}
N 2590 -3740 2590 -3710 {
lab=#net58}
N 2590 -3890 2590 -3850 {
lab=#net57}
N 2590 -4040 2590 -4010 {
lab=#net56}
N 2590 -4190 2590 -4160 {
lab=#net55}
N 2590 -4340 2590 -4310 {
lab=#net54}
N 2590 -4490 2590 -4460 {
lab=#net53}
N 2590 -4640 2590 -4610 {
lab=#net52}
N 2590 -4790 2590 -4760 {
lab=#net51}
N 2590 -4940 2590 -4910 {
lab=#net50}
N 2590 -5090 2590 -5060 {
lab=#net49}
N 2590 -5240 2590 -5210 {
lab=#net48}
N 2590 -5390 2590 -5360 {
lab=#net47}
N 2590 -5550 2590 -5520 {
lab=#net46}
N 2590 -5700 2590 -5680 {
lab=#net45}
N 2590 -5850 2590 -5830 {
lab=#net44}
N 2590 -6000 2590 -5970 {
lab=#net43}
N 2590 -6150 2590 -6130 {
lab=#net42}
N 2590 -6300 2590 -6270 {
lab=#net41}
N 2590 -6450 2590 -6420 {
lab=#net40}
N 2590 -6600 2590 -6570 {
lab=#net39}
N 2590 -6750 2590 -6720 {
lab=#net38}
N 2590 -6900 2590 -6870 {
lab=#net37}
N 2590 -7050 2590 -7040 {
lab=#net36}
N 2590 -7200 2590 -7180 {
lab=#net35}
N 2600 -7630 2900 -7630 {
lab=#net33}
N 2600 -7630 2600 -7500 {
lab=#net33}
N 2600 -7480 2900 -7480 {
lab=#net34}
N 2600 -7480 2600 -7350 {
lab=#net34}
N 2600 -7330 2900 -7330 {
lab=#net35}
N 2600 -7330 2600 -7200 {
lab=#net35}
N 2600 -7180 2900 -7180 {
lab=#net36}
N 2600 -7180 2600 -7050 {
lab=#net36}
N 2600 -7030 2900 -7030 {
lab=#net37}
N 2600 -6880 2900 -6880 {
lab=#net38}
N 2600 -6730 2900 -6730 {
lab=#net39}
N 2600 -6580 2900 -6580 {
lab=#net40}
N 2600 -6430 2900 -6430 {
lab=#net41}
N 2600 -6280 2900 -6280 {
lab=#net42}
N 2600 -6130 2900 -6130 {
lab=#net43}
N 2600 -5980 2900 -5980 {
lab=#net44}
N 2600 -5830 2900 -5830 {
lab=#net45}
N 2600 -5680 2900 -5680 {
lab=#net46}
N 2600 -5530 2900 -5530 {
lab=#net47}
N 2600 -5370 2900 -5370 {
lab=#net48}
N 2600 -5220 2900 -5220 {
lab=#net49}
N 2600 -5070 2900 -5070 {
lab=#net50}
N 2600 -4920 2900 -4920 {
lab=#net51}
N 2600 -4770 2900 -4770 {
lab=#net52}
N 2600 -4620 2900 -4620 {
lab=#net53}
N 2600 -4470 2900 -4470 {
lab=#net54}
N 2600 -4320 2900 -4320 {
lab=#net55}
N 2600 -4170 2900 -4170 {
lab=#net56}
N 2600 -4020 2900 -4020 {
lab=#net57}
N 2600 -3870 2900 -3870 {
lab=#net58}
N 2600 -3720 2900 -3720 {
lab=#net59}
N 2600 -3570 2900 -3570 {
lab=#net60}
N 2600 -3420 2900 -3420 {
lab=#net61}
N 2600 -3270 2900 -3270 {
lab=#net62}
N 2600 -3120 2900 -3120 {
lab=#net63}
N 2600 -3120 2600 -2990 {
lab=#net63}
N 2600 -3270 2600 -3140 {
lab=#net62}
N 2600 -3420 2600 -3290 {
lab=#net61}
N 2600 -3870 2600 -3740 {
lab=#net58}
N 2600 -3720 2600 -3590 {
lab=#net59}
N 2600 -3570 2600 -3440 {
lab=#net60}
N 2600 -4020 2600 -3890 {
lab=#net57}
N 2600 -4170 2600 -4040 {
lab=#net56}
N 2600 -4320 2600 -4190 {
lab=#net55}
N 2600 -4470 2600 -4340 {
lab=#net54}
N 2600 -4620 2600 -4490 {
lab=#net53}
N 2600 -4770 2600 -4640 {
lab=#net52}
N 2600 -4920 2600 -4790 {
lab=#net51}
N 2600 -5070 2600 -4940 {
lab=#net50}
N 2600 -5220 2600 -5090 {
lab=#net49}
N 2600 -5370 2600 -5240 {
lab=#net48}
N 2600 -5530 2600 -5390 {
lab=#net47}
N 2600 -5680 2600 -5550 {
lab=#net46}
N 2600 -5830 2600 -5700 {
lab=#net45}
N 2600 -5980 2600 -5850 {
lab=#net44}
N 2600 -6130 2600 -6010 {
lab=#net43}
N 2600 -6010 2600 -6000 {
lab=#net43}
N 2600 -6280 2600 -6150 {
lab=#net42}
N 2600 -6430 2600 -6300 {
lab=#net41}
N 2600 -6580 2600 -6450 {
lab=#net40}
N 2600 -6730 2600 -6600 {
lab=#net39}
N 2600 -6880 2600 -6750 {
lab=#net38}
N 2600 -7030 2600 -6900 {
lab=#net37}
N 2610 -7610 2900 -7610 {
lab=#net34}
N 2610 -7610 2610 -7350 {
lab=#net34}
N 2620 -7460 2900 -7460 {
lab=#net35}
N 2620 -7460 2620 -7200 {
lab=#net35}
N 2630 -7310 2900 -7310 {
lab=#net36}
N 2630 -7310 2630 -7050 {
lab=#net36}
N 2640 -7160 2900 -7160 {
lab=#net37}
N 2640 -7160 2640 -6900 {
lab=#net37}
N 2650 -7010 2900 -7010 {
lab=#net38}
N 2650 -7010 2650 -6750 {
lab=#net38}
N 2660 -6860 2900 -6860 {
lab=#net39}
N 2660 -6860 2660 -6600 {
lab=#net39}
N 2670 -6710 2900 -6710 {
lab=#net40}
N 2670 -6710 2670 -6450 {
lab=#net40}
N 2680 -6560 2900 -6560 {
lab=#net41}
N 2680 -6560 2680 -6300 {
lab=#net41}
N 2690 -6410 2900 -6410 {
lab=#net42}
N 2690 -6410 2690 -6150 {
lab=#net42}
N 2700 -6260 2900 -6260 {
lab=#net43}
N 2700 -6260 2700 -6000 {
lab=#net43}
N 2710 -6110 2900 -6110 {
lab=#net44}
N 2710 -6110 2710 -5850 {
lab=#net44}
N 2720 -5960 2900 -5960 {
lab=#net45}
N 2720 -5960 2720 -5700 {
lab=#net45}
N 2730 -5810 2900 -5810 {
lab=#net46}
N 2730 -5810 2730 -5550 {
lab=#net46}
N 2740 -5660 2900 -5660 {
lab=#net47}
N 2740 -5660 2740 -5390 {
lab=#net47}
N 2750 -5510 2900 -5510 {
lab=#net48}
N 2750 -5510 2750 -5240 {
lab=#net48}
N 2760 -5350 2900 -5350 {
lab=#net49}
N 2760 -5350 2760 -5090 {
lab=#net49}
N 2770 -5200 2900 -5200 {
lab=#net50}
N 2770 -5200 2770 -4940 {
lab=#net50}
N 2760 -5050 2900 -5050 {
lab=#net51}
N 2760 -5050 2760 -4790 {
lab=#net51}
N 2800 -7760 2800 -3190 {
lab=S1}
N 2750 -4900 2900 -4900 {
lab=#net52}
N 2750 -4900 2750 -4640 {
lab=#net52}
N 2740 -4750 2900 -4750 {
lab=#net53}
N 2740 -4750 2740 -4490 {
lab=#net53}
N 2730 -4600 2900 -4600 {
lab=#net54}
N 2730 -4600 2730 -4340 {
lab=#net54}
N 2720 -4450 2900 -4450 {
lab=#net55}
N 2720 -4450 2720 -4190 {
lab=#net55}
N 2710 -4300 2900 -4300 {
lab=#net56}
N 2710 -4300 2710 -4040 {
lab=#net56}
N 2700 -4150 2900 -4150 {
lab=#net57}
N 2700 -4150 2700 -3890 {
lab=#net57}
N 2690 -4000 2900 -4000 {
lab=#net58}
N 2690 -4000 2690 -3740 {
lab=#net58}
N 2680 -3850 2900 -3850 {
lab=#net59}
N 2680 -3850 2680 -3590 {
lab=#net59}
N 2670 -3700 2900 -3700 {
lab=#net60}
N 2670 -3700 2670 -3440 {
lab=#net60}
N 2660 -3550 2900 -3550 {
lab=#net61}
N 2660 -3550 2660 -3290 {
lab=#net61}
N 2650 -3400 2900 -3400 {
lab=#net62}
N 2650 -3400 2650 -3140 {
lab=#net62}
N 2640 -3250 2900 -3250 {
lab=#net63}
N 2640 -3250 2640 -2990 {
lab=#net63}
N 2380 -2920 2380 -2720 {
lab=l}
N 2420 -5280 2420 -2970 {
lab=S}
N 2420 -7580 2420 -5270 {
lab=S}
N 2420 -7710 2420 -7580 {
lab=S}
N 2440 -7590 2460 -7590 {
lab=l}
N 2440 -7700 2440 -7590 {
lab=l}
N 2420 -7620 2460 -7620 {
lab=S}
N 2420 -7480 2460 -7480 {
lab=S}
N 2420 -7330 2460 -7330 {
lab=S}
N 2420 -7180 2460 -7180 {
lab=S}
N 2420 -7040 2460 -7040 {
lab=S}
N 2420 -6870 2460 -6870 {
lab=S}
N 2420 -6720 2460 -6720 {
lab=S}
N 2420 -6570 2460 -6570 {
lab=S}
N 2420 -6420 2460 -6420 {
lab=S}
N 2420 -6270 2460 -6270 {
lab=S}
N 2420 -6130 2460 -6130 {
lab=S}
N 2420 -5970 2460 -5970 {
lab=S}
N 2420 -5830 2460 -5830 {
lab=S}
N 2420 -5680 2460 -5680 {
lab=S}
N 2420 -5520 2460 -5520 {
lab=S}
N 2420 -5360 2460 -5360 {
lab=S}
N 2420 -5210 2460 -5210 {
lab=S}
N 2420 -5060 2460 -5060 {
lab=S}
N 2420 -4910 2460 -4910 {
lab=S}
N 2420 -4760 2460 -4760 {
lab=S}
N 2420 -4610 2460 -4610 {
lab=S}
N 2420 -4460 2460 -4460 {
lab=S}
N 2420 -4310 2460 -4310 {
lab=S}
N 2420 -4160 2460 -4160 {
lab=S}
N 2420 -4010 2460 -4010 {
lab=S}
N 2420 -3850 2460 -3850 {
lab=S}
N 2420 -3710 2460 -3710 {
lab=S}
N 2420 -3570 2460 -3570 {
lab=S}
N 2420 -3410 2460 -3410 {
lab=S}
N 2420 -3260 2460 -3260 {
lab=S}
N 2420 -3110 2460 -3110 {
lab=S}
N 2420 -2970 2460 -2970 {
lab=S}
N 3090 -7700 3150 -7700 {
lab=#net1}
N 3090 -7550 3150 -7550 {
lab=#net2}
N 3090 -7400 3150 -7400 {
lab=#net3}
N 3090 -7250 3150 -7250 {
lab=#net4}
N 3090 -7100 3150 -7100 {
lab=#net5}
N 3090 -6950 3150 -6950 {
lab=#net6}
N 3090 -6650 3150 -6650 {
lab=#net7}
N 3090 -6500 3150 -6500 {
lab=#net8}
N 3090 -6350 3150 -6350 {
lab=#net9}
N 3090 -6200 3150 -6200 {
lab=#net10}
N 3090 -6050 3150 -6050 {
lab=#net11}
N 3090 -5750 3150 -5750 {
lab=#net13}
N 3090 -5600 3150 -5600 {
lab=#net14}
N 3090 -5440 3150 -5440 {
lab=#net15}
N 3090 -5290 3150 -5290 {
lab=#net16}
N 3090 -5140 3150 -5140 {
lab=#net17}
N 3090 -4990 3150 -4990 {
lab=#net18}
N 3090 -4840 3150 -4840 {
lab=#net19}
N 3090 -4690 3150 -4690 {
lab=#net20}
N 3090 -4540 3150 -4540 {
lab=#net21}
N 3090 -4390 3150 -4390 {
lab=#net22}
N 3090 -4240 3150 -4240 {
lab=#net23}
N 3090 -4090 3150 -4090 {
lab=#net24}
N 3090 -3940 3150 -3940 {
lab=#net25}
N 3090 -3790 3150 -3790 {
lab=#net26}
N 3090 -3640 3150 -3640 {
lab=#net27}
N 3090 -3340 3150 -3340 {
lab=#net29}
N 3090 -3190 3150 -3190 {
lab=#net30}
N 3090 -3040 3150 -3040 {
lab=#net31}
N 750 -3060 760 -3060 {
lab=A[31]}
N 790 -3210 800 -3210 {
lab=A[30]}
N 2780 -3100 2900 -3100 {
lab=l}
N 2780 -3100 2780 -2950 {
lab=l}
N 2780 -2950 2900 -2950 {
lab=l}
N 2780 -2950 2780 -2870 {
lab=l}
N 2780 -2970 2900 -2970 {
lab=l}
N 2870 -3190 2900 -3190 {
lab=S1}
N 2870 -3190 2870 -3180 {
lab=S1}
N 2800 -3180 2870 -3180 {
lab=S1}
N 3990 -7800 3990 -5490 {
lab=S2}
N 3990 -7700 4090 -7700 {
lab=S2}
N 3990 -7550 4090 -7550 {
lab=S2}
N 3990 -7400 4090 -7400 {
lab=S2}
N 3990 -7250 4090 -7250 {
lab=S2}
N 3990 -7100 4090 -7100 {
lab=S2}
N 3990 -6950 4090 -6950 {
lab=S2}
N 3990 -6800 4090 -6800 {
lab=S2}
N 3990 -6650 4090 -6650 {
lab=S2}
N 3990 -6500 4090 -6500 {
lab=S2}
N 3570 -7700 3980 -7700 {
lab=#net1}
N 3980 -7700 3980 -7670 {
lab=#net1}
N 3980 -7670 4090 -7670 {
lab=#net1}
N 3570 -7550 3980 -7550 {
lab=#net2}
N 3980 -7550 3980 -7520 {
lab=#net2}
N 3980 -7520 4090 -7520 {
lab=#net2}
N 3570 -7400 3980 -7400 {
lab=#net3}
N 3980 -7400 3980 -7370 {
lab=#net3}
N 3980 -7370 4090 -7370 {
lab=#net3}
N 3570 -7250 3980 -7250 {
lab=#net4}
N 3980 -7250 3980 -7220 {
lab=#net4}
N 3980 -7220 4090 -7220 {
lab=#net4}
N 3570 -7100 3980 -7100 {
lab=#net5}
N 3980 -7100 3980 -7070 {
lab=#net5}
N 3980 -7070 4090 -7070 {
lab=#net5}
N 3570 -6950 3980 -6950 {
lab=#net6}
N 3980 -6950 3980 -6920 {
lab=#net6}
N 3980 -6920 4090 -6920 {
lab=#net6}
N 3980 -6800 3980 -6780 {
lab=#net64}
N 3980 -6780 3980 -6770 {
lab=#net64}
N 3980 -6770 4090 -6770 {
lab=#net64}
N 3570 -6650 3980 -6650 {
lab=#net7}
N 3980 -6650 3980 -6620 {
lab=#net7}
N 3980 -6620 4090 -6620 {
lab=#net7}
N 3570 -6500 3980 -6500 {
lab=#net8}
N 3980 -6500 3980 -6470 {
lab=#net8}
N 3980 -6470 4090 -6470 {
lab=#net8}
N 3570 -6350 3980 -6350 {
lab=#net9}
N 3570 -6200 3980 -6200 {
lab=#net10}
N 3570 -6050 3980 -6050 {
lab=#net11}
N 3570 -5900 3980 -5900 {
lab=#net12}
N 3570 -5750 3980 -5750 {
lab=#net13}
N 3570 -5600 3980 -5600 {
lab=#net14}
N 3570 -5440 3980 -5440 {
lab=#net15}
N 3980 -6350 3980 -6320 {
lab=#net9}
N 3980 -6200 3980 -6170 {
lab=#net10}
N 3980 -6050 3980 -6020 {
lab=#net11}
N 3980 -5900 3980 -5870 {
lab=#net12}
N 3980 -5750 3980 -5720 {
lab=#net13}
N 3980 -5600 3980 -5570 {
lab=#net14}
N 3980 -6320 4090 -6320 {
lab=#net9}
N 3980 -6170 4090 -6170 {
lab=#net10}
N 3980 -6020 4090 -6020 {
lab=#net11}
N 3980 -5870 4090 -5870 {
lab=#net12}
N 3980 -5720 4090 -5720 {
lab=#net13}
N 3980 -5570 4090 -5570 {
lab=#net14}
N 3980 -5420 4090 -5420 {
lab=#net15}
N 3980 -5440 3980 -5420 {
lab=#net15}
N 3990 -5370 3990 -3060 {
lab=S2}
N 3990 -5290 4090 -5290 {
lab=S2}
N 3990 -5140 4090 -5140 {
lab=S2}
N 3990 -4990 4090 -4990 {
lab=S2}
N 3990 -4840 4090 -4840 {
lab=S2}
N 3990 -4690 4090 -4690 {
lab=S2}
N 3990 -4540 4090 -4540 {
lab=S2}
N 3990 -4390 4090 -4390 {
lab=S2}
N 3990 -4240 4090 -4240 {
lab=S2}
N 3990 -4090 4090 -4090 {
lab=S2}
N 3570 -5290 3980 -5290 {
lab=#net16}
N 3980 -5290 3980 -5260 {
lab=#net16}
N 3980 -5260 4090 -5260 {
lab=#net16}
N 3570 -5140 3980 -5140 {
lab=#net17}
N 3980 -5140 3980 -5110 {
lab=#net17}
N 3980 -5110 4090 -5110 {
lab=#net17}
N 3570 -4990 3980 -4990 {
lab=#net18}
N 3980 -4990 3980 -4960 {
lab=#net18}
N 3980 -4960 4090 -4960 {
lab=#net18}
N 3570 -4840 3980 -4840 {
lab=#net19}
N 3980 -4840 3980 -4810 {
lab=#net19}
N 3980 -4810 4090 -4810 {
lab=#net19}
N 3570 -4690 3980 -4690 {
lab=#net20}
N 3980 -4690 3980 -4660 {
lab=#net20}
N 3980 -4660 4090 -4660 {
lab=#net20}
N 3570 -4540 3980 -4540 {
lab=#net21}
N 3980 -4540 3980 -4510 {
lab=#net21}
N 3980 -4510 4090 -4510 {
lab=#net21}
N 3570 -4390 3980 -4390 {
lab=#net22}
N 3980 -4390 3980 -4370 {
lab=#net22}
N 3980 -4370 3980 -4360 {
lab=#net22}
N 3980 -4360 4090 -4360 {
lab=#net22}
N 3570 -4240 3980 -4240 {
lab=#net23}
N 3980 -4240 3980 -4210 {
lab=#net23}
N 3980 -4210 4090 -4210 {
lab=#net23}
N 3570 -4090 3980 -4090 {
lab=#net24}
N 3980 -4090 3980 -4060 {
lab=#net24}
N 3980 -4060 4090 -4060 {
lab=#net24}
N 3570 -3940 3980 -3940 {
lab=#net25}
N 3570 -3790 3980 -3790 {
lab=#net26}
N 3570 -3640 3980 -3640 {
lab=#net27}
N 3570 -3490 3980 -3490 {
lab=#net28}
N 3570 -3340 3980 -3340 {
lab=#net29}
N 3570 -3190 3980 -3190 {
lab=#net30}
N 3570 -3040 3980 -3040 {
lab=#net31}
N 3980 -3940 3980 -3910 {
lab=#net25}
N 3980 -3790 3980 -3760 {
lab=#net26}
N 3980 -3640 3980 -3610 {
lab=#net27}
N 3980 -3490 3980 -3460 {
lab=#net28}
N 3980 -3340 3980 -3310 {
lab=#net29}
N 3980 -3190 3980 -3160 {
lab=#net30}
N 3980 -3910 4090 -3910 {
lab=#net25}
N 3980 -3760 4090 -3760 {
lab=#net26}
N 3980 -3610 4090 -3610 {
lab=#net27}
N 3980 -3460 4090 -3460 {
lab=#net28}
N 3980 -3310 4090 -3310 {
lab=#net29}
N 3980 -3160 4090 -3160 {
lab=#net30}
N 3980 -3010 4090 -3010 {
lab=#net31}
N 3980 -3030 3980 -3010 {
lab=#net31}
N 3980 -3040 3980 -3030 {
lab=#net31}
N 4220 -4090 4330 -4090 {
lab=O[24]}
N 4220 -3940 4330 -3940 {
lab=O[25]}
N 4220 -3790 4330 -3790 {
lab=O[26]}
N 4220 -3640 4330 -3640 {
lab=O[27]}
N 4220 -3490 4330 -3490 {
lab=O[28]}
N 4220 -3340 4330 -3340 {
lab=O[29]}
N 4220 -3190 4330 -3190 {
lab=O[30]}
N 4220 -3040 4330 -3040 {
lab=O[31]}
N 4220 -5290 4330 -5290 {
lab=O[16]}
N 4220 -5140 4330 -5140 {
lab=O[17]}
N 4220 -4990 4330 -4990 {
lab=O[18]}
N 4220 -4840 4330 -4840 {
lab=O[19]}
N 4220 -4690 4330 -4690 {
lab=O[20]}
N 4220 -4540 4330 -4540 {
lab=O[21]}
N 4220 -4390 4330 -4390 {
lab=O[22]}
N 4220 -4240 4330 -4240 {
lab=O[23]}
N 4220 -6500 4330 -6500 {
lab=O[8]}
N 4220 -6350 4330 -6350 {
lab=O[9]}
N 4220 -6200 4330 -6200 {
lab=O[10]}
N 4220 -6050 4330 -6050 {
lab=O[11]}
N 4220 -5900 4330 -5900 {
lab=O[12]}
N 4220 -5750 4330 -5750 {
lab=O[13]}
N 4220 -5600 4330 -5600 {
lab=O[14]}
N 4220 -7700 4330 -7700 {
lab=O[0]}
N 4220 -7550 4330 -7550 {
lab=O[1]}
N 4220 -7400 4330 -7400 {
lab=O[2]}
N 4220 -7250 4330 -7250 {
lab=O[3]}
N 4220 -7100 4330 -7100 {
lab=O[4]}
N 4220 -6950 4330 -6950 {
lab=O[5]}
N 4220 -6800 4330 -6800 {
lab=O[6]}
N 4220 -6650 4330 -6650 {
lab=O[7]}
N 3990 -3040 4090 -3040 {
lab=S2}
N 3990 -3060 3990 -3040 {
lab=S2}
N 3990 -3190 4090 -3190 {
lab=S2}
N 3990 -3340 4090 -3340 {
lab=S2}
N 3990 -3490 4090 -3490 {
lab=S2}
N 3990 -3640 4090 -3640 {
lab=S2}
N 3990 -3790 4090 -3790 {
lab=S2}
N 3990 -3940 4090 -3940 {
lab=S2}
N 3990 -6350 4090 -6350 {
lab=S2}
N 3990 -6200 4090 -6200 {
lab=S2}
N 3990 -6050 4090 -6050 {
lab=S2}
N 3990 -5900 4090 -5900 {
lab=S2}
N 3990 -5750 4090 -5750 {
lab=S2}
N 3990 -5600 4090 -5600 {
lab=S2}
N 3990 -5450 4090 -5450 {
lab=S2}
N 3280 -6820 3290 -6820 {
lab=#net64}
N 3420 -7650 3420 -7620 {
lab=#net65}
N 3420 -7500 3420 -7480 {
lab=#net66}
N 3420 -7350 3420 -7330 {
lab=#net67}
N 3420 -2990 3420 -2970 {
lab=#net68}
N 3420 -3140 3420 -3110 {
lab=#net69}
N 3420 -3290 3420 -3260 {
lab=#net70}
N 3420 -3440 3420 -3410 {
lab=#net71}
N 3420 -3590 3420 -3570 {
lab=#net72}
N 3420 -3740 3420 -3710 {
lab=#net73}
N 3420 -3890 3420 -3850 {
lab=#net74}
N 3420 -4040 3420 -4010 {
lab=#net75}
N 3420 -4190 3420 -4160 {
lab=#net76}
N 3420 -4340 3420 -4310 {
lab=#net77}
N 3420 -4490 3420 -4460 {
lab=#net78}
N 3420 -4640 3420 -4610 {
lab=#net79}
N 3420 -4790 3420 -4760 {
lab=#net80}
N 3420 -4940 3420 -4910 {
lab=#net81}
N 3420 -5090 3420 -5060 {
lab=#net82}
N 3420 -5240 3420 -5210 {
lab=#net83}
N 3420 -5390 3420 -5360 {
lab=#net84}
N 3420 -5550 3420 -5520 {
lab=#net85}
N 3420 -5700 3420 -5680 {
lab=#net86}
N 3420 -5850 3420 -5830 {
lab=#net87}
N 3420 -6000 3420 -5970 {
lab=#net88}
N 3420 -6150 3420 -6130 {
lab=#net89}
N 3420 -6300 3420 -6270 {
lab=#net90}
N 3420 -6450 3420 -6420 {
lab=#net91}
N 3420 -6600 3420 -6570 {
lab=#net92}
N 3420 -6750 3420 -6720 {
lab=#net93}
N 3420 -6900 3420 -6870 {
lab=#net94}
N 3420 -7050 3420 -7040 {
lab=#net95}
N 3420 -7200 3420 -7180 {
lab=#net96}
N 3250 -5280 3250 -2970 {
lab=S}
N 3250 -7580 3250 -5270 {
lab=S}
N 3250 -7710 3250 -7580 {
lab=S}
N 3270 -7590 3290 -7590 {
lab=l}
N 3250 -7620 3290 -7620 {
lab=S}
N 3250 -7480 3290 -7480 {
lab=S}
N 3250 -7330 3290 -7330 {
lab=S}
N 3250 -7180 3290 -7180 {
lab=S}
N 3250 -7040 3290 -7040 {
lab=S}
N 3250 -6870 3290 -6870 {
lab=S}
N 3250 -6720 3290 -6720 {
lab=S}
N 3250 -6570 3290 -6570 {
lab=S}
N 3250 -6420 3290 -6420 {
lab=S}
N 3250 -6270 3290 -6270 {
lab=S}
N 3250 -6130 3290 -6130 {
lab=S}
N 3250 -5970 3290 -5970 {
lab=S}
N 3250 -5830 3290 -5830 {
lab=S}
N 3250 -5680 3290 -5680 {
lab=S}
N 3250 -5520 3290 -5520 {
lab=S}
N 3250 -5360 3290 -5360 {
lab=S}
N 3250 -5210 3290 -5210 {
lab=S}
N 3250 -5060 3290 -5060 {
lab=S}
N 3250 -4910 3290 -4910 {
lab=S}
N 3250 -4760 3290 -4760 {
lab=S}
N 3250 -4610 3290 -4610 {
lab=S}
N 3250 -4460 3290 -4460 {
lab=S}
N 3250 -4310 3290 -4310 {
lab=S}
N 3250 -4160 3290 -4160 {
lab=S}
N 3250 -4010 3290 -4010 {
lab=S}
N 3250 -3850 3290 -3850 {
lab=S}
N 3250 -3710 3290 -3710 {
lab=S}
N 3250 -3570 3290 -3570 {
lab=S}
N 3250 -3410 3290 -3410 {
lab=S}
N 3250 -3260 3290 -3260 {
lab=S}
N 3250 -3110 3290 -3110 {
lab=S}
N 3250 -2970 3290 -2970 {
lab=S}
N 3250 -7760 3250 -7710 {
lab=S}
N 3150 -7550 3570 -7550 {
lab=#net2}
N 3150 -7400 3570 -7400 {
lab=#net3}
N 3150 -7250 3570 -7250 {
lab=#net4}
N 3150 -7100 3570 -7100 {
lab=#net5}
N 3150 -6950 3570 -6950 {
lab=#net6}
N 3150 -6650 3570 -6650 {
lab=#net7}
N 3150 -6500 3570 -6500 {
lab=#net8}
N 3150 -6350 3570 -6350 {
lab=#net9}
N 3150 -6200 3570 -6200 {
lab=#net10}
N 3150 -6050 3570 -6050 {
lab=#net11}
N 3150 -5750 3570 -5750 {
lab=#net13}
N 3150 -5600 3570 -5600 {
lab=#net14}
N 3150 -5440 3570 -5440 {
lab=#net15}
N 3150 -5290 3570 -5290 {
lab=#net16}
N 3150 -5140 3570 -5140 {
lab=#net17}
N 3150 -4990 3570 -4990 {
lab=#net18}
N 3150 -4840 3570 -4840 {
lab=#net19}
N 3150 -4690 3570 -4690 {
lab=#net20}
N 3150 -4540 3570 -4540 {
lab=#net21}
N 3150 -4390 3570 -4390 {
lab=#net22}
N 3150 -4240 3570 -4240 {
lab=#net23}
N 3150 -4090 3570 -4090 {
lab=#net24}
N 3150 -3940 3570 -3940 {
lab=#net25}
N 3150 -3790 3570 -3790 {
lab=#net26}
N 3150 -3640 3570 -3640 {
lab=#net27}
N 3150 -3340 3570 -3340 {
lab=#net29}
N 3150 -3190 3570 -3190 {
lab=#net30}
N 3150 -3040 3570 -3040 {
lab=#net31}
N 3040 -7450 3290 -7450 {
lab=#net1}
N 3040 -7700 3040 -7450 {
lab=#net1}
N 3050 -7550 3050 -7300 {
lab=#net2}
N 3050 -7300 3290 -7300 {
lab=#net2}
N 3060 -7400 3060 -7150 {
lab=#net3}
N 3060 -7150 3290 -7150 {
lab=#net3}
N 3070 -7010 3290 -7010 {
lab=#net4}
N 3080 -6840 3290 -6840 {
lab=#net5}
N 3090 -6690 3300 -6690 {
lab=#net6}
N 3030 -6800 3980 -6800 {
lab=#net64}
N 3090 -6950 3090 -6690 {
lab=#net6}
N 3100 -6800 3100 -6540 {
lab=#net64}
N 3100 -6540 3290 -6540 {
lab=#net64}
N 3110 -6390 3290 -6390 {
lab=#net7}
N 3120 -6500 3120 -6240 {
lab=#net8}
N 3120 -6240 3290 -6240 {
lab=#net8}
N 3130 -6350 3130 -6100 {
lab=#net9}
N 3130 -6100 3290 -6100 {
lab=#net9}
N 3140 -6200 3140 -5940 {
lab=#net10}
N 3140 -5940 3290 -5940 {
lab=#net10}
N 3150 -5800 3290 -5800 {
lab=#net11}
N 3090 -5900 3570 -5900 {
lab=#net12}
N 3150 -6050 3150 -5800 {
lab=#net11}
N 3160 -5900 3160 -5650 {
lab=#net12}
N 3160 -5650 3290 -5650 {
lab=#net12}
N 3170 -5750 3170 -5490 {
lab=#net13}
N 3170 -5490 3290 -5490 {
lab=#net13}
N 3180 -5330 3290 -5330 {
lab=#net14}
N 3180 -5600 3180 -5330 {
lab=#net14}
N 3190 -5440 3190 -5180 {
lab=#net15}
N 3190 -5180 3290 -5180 {
lab=#net15}
N 3200 -5290 3200 -5030 {
lab=#net16}
N 3200 -5030 3290 -5030 {
lab=#net16}
N 3210 -5140 3210 -4880 {
lab=#net17}
N 3210 -4880 3290 -4880 {
lab=#net17}
N 3220 -4990 3220 -4730 {
lab=#net18}
N 3220 -4730 3290 -4730 {
lab=#net18}
N 3230 -4840 3230 -4580 {
lab=#net19}
N 3230 -4580 3290 -4580 {
lab=#net19}
N 3220 -4430 3290 -4430 {
lab=#net20}
N 3220 -4690 3220 -4430 {
lab=#net20}
N 3210 -4280 3290 -4280 {
lab=#net21}
N 3210 -4540 3210 -4280 {
lab=#net21}
N 3200 -4130 3290 -4130 {
lab=#net22}
N 3200 -4390 3200 -4130 {
lab=#net22}
N 3190 -3980 3290 -3980 {
lab=#net23}
N 3190 -4240 3190 -3980 {
lab=#net23}
N 3180 -3820 3290 -3820 {
lab=#net24}
N 3180 -4090 3180 -3820 {
lab=#net24}
N 3170 -3680 3290 -3680 {
lab=#net25}
N 3170 -3940 3170 -3680 {
lab=#net25}
N 3160 -3540 3290 -3540 {
lab=#net26}
N 3160 -3790 3160 -3540 {
lab=#net26}
N 3150 -3380 3290 -3380 {
lab=#net27}
N 3150 -3640 3150 -3380 {
lab=#net27}
N 3140 -3230 3290 -3230 {
lab=#net28}
N 3140 -3490 3140 -3230 {
lab=#net28}
N 3090 -3490 3570 -3490 {
lab=#net28}
N 3130 -3080 3290 -3080 {
lab=#net29}
N 3130 -3340 3130 -3080 {
lab=#net29}
N 3120 -2940 3290 -2940 {
lab=#net30}
N 3120 -3190 3120 -2940 {
lab=#net30}
N 3420 -7650 4090 -7650 {
lab=#net65}
N 3420 -7500 4090 -7500 {
lab=#net66}
N 3420 -7350 4090 -7350 {
lab=#net67}
N 3420 -7200 4090 -7200 {
lab=#net96}
N 3420 -7050 4090 -7050 {
lab=#net95}
N 3420 -6900 4090 -6900 {
lab=#net94}
N 3420 -6750 4090 -6750 {
lab=#net93}
N 3420 -6600 4090 -6600 {
lab=#net92}
N 3420 -6450 4090 -6450 {
lab=#net91}
N 3420 -6300 4090 -6300 {
lab=#net90}
N 3420 -6150 4090 -6150 {
lab=#net89}
N 3420 -6000 4090 -6000 {
lab=#net88}
N 3420 -5850 4090 -5850 {
lab=#net87}
N 3420 -5700 4090 -5700 {
lab=#net86}
N 3420 -5550 4090 -5550 {
lab=#net85}
N 3420 -5240 4090 -5240 {
lab=#net83}
N 3420 -5090 4090 -5090 {
lab=#net82}
N 3420 -4940 4090 -4940 {
lab=#net81}
N 3420 -4790 4090 -4790 {
lab=#net80}
N 3420 -4640 4090 -4640 {
lab=#net79}
N 3420 -4490 4090 -4490 {
lab=#net78}
N 3420 -4340 4090 -4340 {
lab=#net77}
N 3990 -5490 3990 -5370 {
lab=S2}
N 3420 -5400 4090 -5400 {
lab=#net84}
N 3420 -5400 3420 -5390 {
lab=#net84}
N 3420 -4190 4090 -4190 {
lab=#net76}
N 3420 -4040 4090 -4040 {
lab=#net75}
N 3420 -3890 4090 -3890 {
lab=#net74}
N 3420 -3740 4090 -3740 {
lab=#net73}
N 3420 -3590 4090 -3590 {
lab=#net72}
N 3420 -3440 4090 -3440 {
lab=#net71}
N 3420 -3290 4090 -3290 {
lab=#net70}
N 3420 -3140 4090 -3140 {
lab=#net69}
N 3420 -2990 4090 -2990 {
lab=#net68}
N 3210 -2920 3290 -2920 {
lab=l}
N 3210 -2920 3210 -2720 {
lab=l}
N 3240 -3060 3290 -3060 {
lab=#net31}
N 3240 -3060 3240 -3040 {
lab=#net31}
N 3240 -3210 3290 -3210 {
lab=#net30}
N 3240 -3210 3240 -3190 {
lab=#net30}
N 3240 -3360 3290 -3360 {
lab=#net29}
N 3240 -3360 3240 -3340 {
lab=#net29}
N 3240 -3520 3290 -3520 {
lab=#net28}
N 3240 -3520 3240 -3490 {
lab=#net28}
N 3240 -3660 3290 -3660 {
lab=#net27}
N 3240 -3660 3240 -3640 {
lab=#net27}
N 3240 -3800 3290 -3800 {
lab=#net26}
N 3240 -3800 3240 -3790 {
lab=#net26}
N 3240 -3960 3290 -3960 {
lab=#net25}
N 3240 -3960 3240 -3940 {
lab=#net25}
N 3240 -4110 3290 -4110 {
lab=#net24}
N 3240 -4110 3240 -4090 {
lab=#net24}
N 3240 -4260 3290 -4260 {
lab=#net23}
N 3240 -4260 3240 -4240 {
lab=#net23}
N 3240 -4410 3290 -4410 {
lab=#net22}
N 3240 -4410 3240 -4390 {
lab=#net22}
N 3240 -4560 3290 -4560 {
lab=#net21}
N 3240 -4560 3240 -4540 {
lab=#net21}
N 3240 -4710 3290 -4710 {
lab=#net20}
N 3240 -4710 3240 -4690 {
lab=#net20}
N 3240 -4860 3290 -4860 {
lab=#net19}
N 3240 -4860 3240 -4840 {
lab=#net19}
N 3240 -5010 3290 -5010 {
lab=#net18}
N 3240 -5010 3240 -4990 {
lab=#net18}
N 3240 -5160 3290 -5160 {
lab=#net17}
N 3240 -5160 3240 -5140 {
lab=#net17}
N 3240 -5310 3290 -5310 {
lab=#net16}
N 3240 -5310 3240 -5290 {
lab=#net16}
N 3240 -5470 3290 -5470 {
lab=#net15}
N 3240 -5470 3240 -5440 {
lab=#net15}
N 3240 -5630 3290 -5630 {
lab=#net14}
N 3240 -5630 3240 -5600 {
lab=#net14}
N 3240 -5780 3290 -5780 {
lab=#net13}
N 3240 -5780 3240 -5750 {
lab=#net13}
N 3240 -5920 3290 -5920 {
lab=#net12}
N 3240 -5920 3240 -5900 {
lab=#net12}
N 3240 -6080 3290 -6080 {
lab=#net11}
N 3240 -6080 3240 -6050 {
lab=#net11}
N 3240 -6220 3290 -6220 {
lab=#net10}
N 3240 -6220 3240 -6200 {
lab=#net10}
N 3240 -6370 3290 -6370 {
lab=#net9}
N 3240 -6370 3240 -6350 {
lab=#net9}
N 3240 -6520 3290 -6520 {
lab=#net8}
N 3240 -6520 3240 -6500 {
lab=#net8}
N 3240 -6670 3290 -6670 {
lab=#net7}
N 3240 -6670 3240 -6650 {
lab=#net7}
N 3240 -6820 3280 -6820 {
lab=#net64}
N 3240 -6820 3240 -6800 {
lab=#net64}
N 3240 -6990 3290 -6990 {
lab=#net6}
N 3240 -6990 3240 -6950 {
lab=#net6}
N 3230 -7130 3290 -7130 {
lab=#net5}
N 3230 -7130 3230 -7100 {
lab=#net5}
N 3240 -7280 3290 -7280 {
lab=#net4}
N 3240 -7280 3240 -7250 {
lab=#net4}
N 3240 -7430 3290 -7430 {
lab=#net3}
N 3240 -7430 3240 -7400 {
lab=#net3}
N 3230 -7570 3290 -7570 {
lab=#net2}
N 3230 -7570 3230 -7550 {
lab=#net2}
N 3150 -7700 3570 -7700 {
lab=#net1}
N 3270 -7770 3270 -7590 {
lab=l}
N 4330 -7700 4390 -7700 {
lab=O[0]}
N 4330 -7550 4390 -7550 {
lab=O[1]}
N 4330 -7400 4390 -7400 {
lab=O[2]}
N 4330 -7250 4390 -7250 {
lab=O[3]}
N 4330 -7100 4390 -7100 {
lab=O[4]}
N 4330 -6950 4390 -6950 {
lab=O[5]}
N 4330 -6800 4390 -6800 {
lab=O[6]}
N 4330 -6650 4390 -6650 {
lab=O[7]}
N 4330 -6500 4390 -6500 {
lab=O[8]}
N 4330 -6350 4390 -6350 {
lab=O[9]}
N 4330 -6200 4390 -6200 {
lab=O[10]}
N 4330 -6050 4390 -6050 {
lab=O[11]}
N 4330 -5900 4390 -5900 {
lab=O[12]}
N 4330 -5750 4390 -5750 {
lab=O[13]}
N 4330 -5600 4390 -5600 {
lab=O[14]}
N 4330 -5440 4390 -5440 {
lab=O[15]}
N 4330 -5290 4390 -5290 {
lab=O[16]}
N 4330 -5140 4390 -5140 {
lab=O[17]}
N 4330 -4990 4390 -4990 {
lab=O[18]}
N 4330 -4840 4390 -4840 {
lab=O[19]}
N 4330 -4690 4390 -4690 {
lab=O[20]}
N 4330 -4540 4390 -4540 {
lab=O[21]}
N 4330 -4390 4390 -4390 {
lab=O[22]}
N 4330 -4240 4390 -4240 {
lab=O[23]}
N 4330 -4090 4390 -4090 {
lab=O[24]}
N 4330 -3940 4390 -3940 {
lab=O[25]}
N 4330 -3790 4390 -3790 {
lab=O[26]}
N 4330 -3640 4390 -3640 {
lab=O[27]}
N 4330 -3490 4390 -3490 {
lab=O[28]}
N 4330 -3340 4390 -3340 {
lab=O[29]}
N 4330 -3190 4390 -3190 {
lab=O[30]}
N 4330 -3040 4390 -3040 {
lab=O[31]}
N 4400 -7730 4400 -2970 {
lab=O[31:0]
bus=true}
N 4220 -5450 4330 -5450 {
lab=O[15]}
N 4330 -5450 4330 -5440 {
lab=O[15]}
N 3110 -6650 3110 -6390 {
lab=#net7}
N 3080 -7100 3080 -6840 {
lab=#net5}
N 3070 -7250 3070 -7010 {
lab=#net4}
C {4x1_mux.sym} 2970 -7640 0 0 {name=x1}
C {4x1_mux.sym} 2970 -7490 0 0 {name=x2}
C {4x1_mux.sym} 2970 -7340 0 0 {name=x3}
C {4x1_mux.sym} 2970 -7190 0 0 {name=x4}
C {4x1_mux.sym} 2970 -7040 0 0 {name=x5}
C {4x1_mux.sym} 2970 -6890 0 0 {name=x6}
C {4x1_mux.sym} 2970 -6740 0 0 {name=x7}
C {4x1_mux.sym} 2970 -6590 0 0 {name=x8}
C {4x1_mux.sym} 2970 -6440 0 0 {name=x9}
C {4x1_mux.sym} 2970 -6290 0 0 {name=x10}
C {4x1_mux.sym} 2970 -6140 0 0 {name=x11}
C {4x1_mux.sym} 2970 -5990 0 0 {name=x12}
C {4x1_mux.sym} 2970 -5840 0 0 {name=x13}
C {4x1_mux.sym} 2970 -5690 0 0 {name=x14}
C {4x1_mux.sym} 2970 -5540 0 0 {name=x15}
C {4x1_mux.sym} 2970 -5380 0 0 {name=x16}
C {4x1_mux.sym} 2970 -5230 0 0 {name=x17}
C {4x1_mux.sym} 2970 -5080 0 0 {name=x18}
C {4x1_mux.sym} 2970 -4930 0 0 {name=x19}
C {4x1_mux.sym} 2970 -4780 0 0 {name=x20}
C {4x1_mux.sym} 2970 -4630 0 0 {name=x21}
C {4x1_mux.sym} 2970 -4480 0 0 {name=x22}
C {4x1_mux.sym} 2970 -4330 0 0 {name=x23}
C {4x1_mux.sym} 2970 -4180 0 0 {name=x24}
C {4x1_mux.sym} 2970 -4030 0 0 {name=x25}
C {4x1_mux.sym} 2970 -3880 0 0 {name=x26}
C {4x1_mux.sym} 2970 -3730 0 0 {name=x27}
C {4x1_mux.sym} 2970 -3580 0 0 {name=x28}
C {4x1_mux.sym} 2970 -3430 0 0 {name=x29}
C {4x1_mux.sym} 2970 -3280 0 0 {name=x30}
C {devices/bus_tap.sym} 1990 -7750 1 0 {name=l1 lab=[0]}
C {devices/bus_tap.sym} 1950 -7750 1 0 {name=l2 lab=[1]}
C {devices/bus_tap.sym} 1910 -7750 1 0 {name=l3 lab=[2]}
C {devices/bus_tap.sym} 1870 -7750 1 0 {name=l4 lab=[3]}
C {devices/bus_tap.sym} 1830 -7750 1 0 {name=l5 lab=[4]}
C {devices/bus_tap.sym} 1790 -7750 1 0 {name=l6 lab=[5]}
C {devices/bus_tap.sym} 1750 -7750 1 0 {name=l7 lab=[6]}
C {devices/bus_tap.sym} 1710 -7750 1 0 {name=l8 lab=[7]}
C {devices/bus_tap.sym} 1670 -7750 1 0 {name=l9 lab=[8]}
C {devices/bus_tap.sym} 1630 -7750 1 0 {name=l10 lab=[9]}
C {devices/bus_tap.sym} 1590 -7750 1 0 {name=l11 lab=[10]}
C {devices/bus_tap.sym} 1550 -7750 1 0 {name=l12 lab=[11]}
C {devices/bus_tap.sym} 1510 -7750 1 0 {name=l13 lab=[12]}
C {devices/bus_tap.sym} 1470 -7750 1 0 {name=l14 lab=[13]}
C {devices/bus_tap.sym} 1430 -7750 1 0 {name=l15 lab=[14]}
C {devices/bus_tap.sym} 1390 -7750 1 0 {name=l16 lab=[15]}
C {devices/bus_tap.sym} 1350 -7750 1 0 {name=l17 lab=[16]}
C {devices/bus_tap.sym} 1310 -7750 1 0 {name=l18 lab=[17]}
C {devices/bus_tap.sym} 1270 -7750 1 0 {name=l19 lab=[18]}
C {devices/bus_tap.sym} 1230 -7750 1 0 {name=l20 lab=[19]}
C {devices/bus_tap.sym} 1190 -7750 1 0 {name=l21 lab=[20]}
C {devices/bus_tap.sym} 1150 -7750 1 0 {name=l23 lab=[21]}
C {devices/bus_tap.sym} 1110 -7750 1 0 {name=l24 lab=[22]}
C {devices/bus_tap.sym} 1070 -7750 1 0 {name=l25 lab=[23]}
C {devices/bus_tap.sym} 1030 -7750 1 0 {name=l26 lab=[24]}
C {devices/bus_tap.sym} 990 -7750 1 0 {name=l27 lab=[25]}
C {devices/bus_tap.sym} 950 -7750 1 0 {name=l28 lab=[26]}
C {devices/bus_tap.sym} 910 -7750 1 0 {name=l29 lab=[27]}
C {devices/bus_tap.sym} 870 -7750 1 0 {name=l30 lab=[28]}
C {devices/bus_tap.sym} 830 -7750 1 0 {name=l31 lab=[29]}
C {devices/bus_tap.sym} 780 -7750 1 0 {name=l22 lab=[30]}
C {devices/bus_tap.sym} 740 -7750 1 0 {name=l32 lab=[31]}
C {4x1_mux.sym} 2970 -3130 0 0 {name=x31}
C {4x1_mux.sym} 2970 -2980 0 0 {name=x32}
C {2x1_mux.sym} 2520 -7590 0 0 {name=x67}
C {2x1_mux.sym} 2520 -7450 0 0 {name=x68}
C {2x1_mux.sym} 2520 -7300 0 0 {name=x69}
C {2x1_mux.sym} 2520 -7150 0 0 {name=x70}
C {2x1_mux.sym} 2520 -7010 0 0 {name=x71}
C {2x1_mux.sym} 2520 -6840 0 0 {name=x72}
C {2x1_mux.sym} 2520 -6690 0 0 {name=x73}
C {2x1_mux.sym} 2520 -6540 0 0 {name=x74}
C {2x1_mux.sym} 2520 -6390 0 0 {name=x75}
C {2x1_mux.sym} 2520 -6240 0 0 {name=x76}
C {2x1_mux.sym} 2520 -6100 0 0 {name=x77}
C {2x1_mux.sym} 2520 -5940 0 0 {name=x78}
C {2x1_mux.sym} 2520 -5800 0 0 {name=x79}
C {2x1_mux.sym} 2520 -5650 0 0 {name=x80}
C {2x1_mux.sym} 2520 -5490 0 0 {name=x81}
C {2x1_mux.sym} 2520 -5330 0 0 {name=x82}
C {2x1_mux.sym} 2520 -5180 0 0 {name=x83}
C {2x1_mux.sym} 2520 -5030 0 0 {name=x84}
C {2x1_mux.sym} 2520 -4880 0 0 {name=x85}
C {2x1_mux.sym} 2520 -4730 0 0 {name=x86}
C {2x1_mux.sym} 2520 -4580 0 0 {name=x87}
C {2x1_mux.sym} 2520 -4430 0 0 {name=x88}
C {2x1_mux.sym} 2520 -4280 0 0 {name=x89}
C {2x1_mux.sym} 2520 -4130 0 0 {name=x90}
C {2x1_mux.sym} 2520 -3980 0 0 {name=x91}
C {2x1_mux.sym} 2520 -3820 0 0 {name=x92}
C {2x1_mux.sym} 2520 -3680 0 0 {name=x93}
C {2x1_mux.sym} 2520 -3540 0 0 {name=x94}
C {2x1_mux.sym} 2520 -3380 0 0 {name=x95}
C {2x1_mux.sym} 2520 -3230 0 0 {name=x96}
C {2x1_mux.sym} 2520 -3080 0 0 {name=x97}
C {2x1_mux.sym} 2520 -2940 0 0 {name=x98}
C {devices/ipin.sym} 740 -7750 0 0 {name=p16 sig_type=std_logic lab=A[31:0]}
C {devices/ipin.sym} 2850 -7760 1 0 {name=p2 sig_type=std_logic lab=S0}
C {devices/ipin.sym} 2800 -7760 1 0 {name=p8 sig_type=std_logic lab=S1}
C {devices/ipin.sym} 2420 -7710 1 0 {name=p17 sig_type=std_logic lab=S}
C {devices/ipin.sym} 2440 -7700 1 0 {name=p3 sig_type=std_logic lab=l}
C {devices/ipin.sym} 2380 -2720 1 0 {name=p4 sig_type=std_logic lab=l}
C {devices/ipin.sym} 2780 -2870 1 0 {name=p5 sig_type=std_logic lab=l}
C {2x1_mux.sym} 4150 -7670 0 0 {name=x33}
C {2x1_mux.sym} 4150 -7520 0 0 {name=x34}
C {2x1_mux.sym} 4150 -7370 0 0 {name=x35}
C {2x1_mux.sym} 4150 -7220 0 0 {name=x36}
C {2x1_mux.sym} 4150 -7070 0 0 {name=x37}
C {2x1_mux.sym} 4150 -6920 0 0 {name=x38}
C {2x1_mux.sym} 4150 -6770 0 0 {name=x39}
C {2x1_mux.sym} 4150 -6620 0 0 {name=x40}
C {2x1_mux.sym} 4150 -6470 0 0 {name=x41}
C {2x1_mux.sym} 4150 -6320 0 0 {name=x42}
C {2x1_mux.sym} 4150 -6170 0 0 {name=x43}
C {2x1_mux.sym} 4150 -6020 0 0 {name=x44}
C {2x1_mux.sym} 4150 -5870 0 0 {name=x45}
C {2x1_mux.sym} 4150 -5720 0 0 {name=x46}
C {2x1_mux.sym} 4150 -5570 0 0 {name=x47}
C {2x1_mux.sym} 4150 -5420 0 0 {name=x48}
C {2x1_mux.sym} 4150 -5260 0 0 {name=x49}
C {2x1_mux.sym} 4150 -5110 0 0 {name=x50}
C {2x1_mux.sym} 4150 -4960 0 0 {name=x51}
C {2x1_mux.sym} 4150 -4810 0 0 {name=x52}
C {2x1_mux.sym} 4150 -4660 0 0 {name=x53}
C {2x1_mux.sym} 4150 -4510 0 0 {name=x54}
C {2x1_mux.sym} 4150 -4360 0 0 {name=x55}
C {2x1_mux.sym} 4150 -4210 0 0 {name=x56}
C {2x1_mux.sym} 4150 -4060 0 0 {name=x57}
C {2x1_mux.sym} 4150 -3910 0 0 {name=x58}
C {2x1_mux.sym} 4150 -3760 0 0 {name=x59}
C {2x1_mux.sym} 4150 -3610 0 0 {name=x60}
C {2x1_mux.sym} 4150 -3460 0 0 {name=x61}
C {2x1_mux.sym} 4150 -3310 0 0 {name=x62}
C {2x1_mux.sym} 4150 -3160 0 0 {name=x63}
C {2x1_mux.sym} 4150 -3010 0 0 {name=x64}
C {2x1_mux.sym} 3350 -7590 0 0 {name=x65}
C {2x1_mux.sym} 3350 -7450 0 0 {name=x66}
C {2x1_mux.sym} 3350 -7300 0 0 {name=x99}
C {2x1_mux.sym} 3350 -7150 0 0 {name=x100}
C {2x1_mux.sym} 3350 -7010 0 0 {name=x101}
C {2x1_mux.sym} 3350 -6840 0 0 {name=x102}
C {2x1_mux.sym} 3350 -6690 0 0 {name=x103}
C {2x1_mux.sym} 3350 -6540 0 0 {name=x104}
C {2x1_mux.sym} 3350 -6390 0 0 {name=x105}
C {2x1_mux.sym} 3350 -6240 0 0 {name=x106}
C {2x1_mux.sym} 3350 -6100 0 0 {name=x107}
C {2x1_mux.sym} 3350 -5940 0 0 {name=x108}
C {2x1_mux.sym} 3350 -5800 0 0 {name=x109}
C {2x1_mux.sym} 3350 -5650 0 0 {name=x110}
C {2x1_mux.sym} 3350 -5490 0 0 {name=x111}
C {2x1_mux.sym} 3350 -5330 0 0 {name=x112}
C {2x1_mux.sym} 3350 -5180 0 0 {name=x113}
C {2x1_mux.sym} 3350 -5030 0 0 {name=x114}
C {2x1_mux.sym} 3350 -4880 0 0 {name=x115}
C {2x1_mux.sym} 3350 -4730 0 0 {name=x116}
C {2x1_mux.sym} 3350 -4580 0 0 {name=x117}
C {2x1_mux.sym} 3350 -4430 0 0 {name=x118}
C {2x1_mux.sym} 3350 -4280 0 0 {name=x119}
C {2x1_mux.sym} 3350 -4130 0 0 {name=x120}
C {2x1_mux.sym} 3350 -3980 0 0 {name=x121}
C {2x1_mux.sym} 3350 -3820 0 0 {name=x122}
C {2x1_mux.sym} 3350 -3680 0 0 {name=x123}
C {2x1_mux.sym} 3350 -3540 0 0 {name=x124}
C {2x1_mux.sym} 3350 -3380 0 0 {name=x125}
C {2x1_mux.sym} 3350 -3230 0 0 {name=x126}
C {2x1_mux.sym} 3350 -3080 0 0 {name=x127}
C {2x1_mux.sym} 3350 -2940 0 0 {name=x128}
C {devices/ipin.sym} 3250 -7760 1 0 {name=p6 sig_type=std_logic lab=S}
C {devices/ipin.sym} 3270 -7770 1 0 {name=p7 sig_type=std_logic lab=l}
C {devices/ipin.sym} 3210 -2720 3 0 {name=p9 sig_type=std_logic lab=l}
C {devices/bus_tap.sym} 4400 -7690 0 1 {name=l33 lab=[0]}
C {devices/bus_tap.sym} 4400 -7540 0 1 {name=l34 lab=[1]}
C {devices/bus_tap.sym} 4400 -7390 0 1 {name=l35 lab=[2]}
C {devices/bus_tap.sym} 4400 -7240 0 1 {name=l36 lab=[3]}
C {devices/bus_tap.sym} 4400 -7090 0 1 {name=l37 lab=[4]}
C {devices/bus_tap.sym} 4400 -6940 0 1 {name=l38 lab=[5]}
C {devices/bus_tap.sym} 4400 -6790 0 1 {name=l39 lab=[6]}
C {devices/bus_tap.sym} 4400 -6640 0 1 {name=l40 lab=[7]}
C {devices/bus_tap.sym} 4400 -6490 0 1 {name=l41 lab=[8]}
C {devices/bus_tap.sym} 4400 -6340 0 1 {name=l42 lab=[9]}
C {devices/bus_tap.sym} 4400 -6190 0 1 {name=l43 lab=[10]}
C {devices/bus_tap.sym} 4400 -6040 0 1 {name=l44 lab=[11]}
C {devices/bus_tap.sym} 4400 -5890 0 1 {name=l45 lab=[12]}
C {devices/bus_tap.sym} 4400 -5740 0 1 {name=l46 lab=[13]}
C {devices/bus_tap.sym} 4400 -5590 0 1 {name=l47 lab=[14]}
C {devices/bus_tap.sym} 4400 -5430 0 1 {name=l48 lab=[15]}
C {devices/bus_tap.sym} 4400 -5280 0 1 {name=l49 lab=[16]}
C {devices/bus_tap.sym} 4400 -5130 0 1 {name=l50 lab=[17]}
C {devices/bus_tap.sym} 4400 -4980 0 1 {name=l51 lab=[18]}
C {devices/bus_tap.sym} 4400 -4830 0 1 {name=l52 lab=[19]}
C {devices/bus_tap.sym} 4400 -4680 0 1 {name=l53 lab=[20]}
C {devices/bus_tap.sym} 4400 -4530 0 1 {name=l54 lab=[21]}
C {devices/bus_tap.sym} 4400 -4380 0 1 {name=l55 lab=[22]}
C {devices/bus_tap.sym} 4400 -4230 0 1 {name=l56 lab=[23]}
C {devices/bus_tap.sym} 4400 -4080 0 1 {name=l57 lab=[24]}
C {devices/bus_tap.sym} 4400 -3930 0 1 {name=l58 lab=[25]}
C {devices/bus_tap.sym} 4400 -3780 0 1 {name=l59 lab=[26]}
C {devices/bus_tap.sym} 4400 -3630 0 1 {name=l60 lab=[27]}
C {devices/bus_tap.sym} 4400 -3480 0 1 {name=l61 lab=[28]}
C {devices/bus_tap.sym} 4400 -3330 0 1 {name=l62 lab=[29]}
C {devices/bus_tap.sym} 4400 -3180 0 1 {name=l63 lab=[30]}
C {devices/bus_tap.sym} 4400 -3030 0 1 {name=l64 lab=[31]}
C {devices/opin.sym} 4400 -7730 1 0 {name=p10 sig_type=std_logic lab=O[31:0]}
C {devices/vsource.sym} 6460 -7210 0 0 {name=VB1 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 6460 -7240 0 0 {name=VB2 sig_type=std_logic lab=A[3]}
C {devices/gnd.sym} 6460 -7180 0 0 {name=l65 lab=GND}
C {devices/vsource.sym} 5900 -7200 0 0 {name=VB3 value="pwl=0 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 5900 -7230 0 0 {name=VB4 sig_type=std_logic lab=A[1]}
C {devices/gnd.sym} 5900 -7170 0 0 {name=l66 lab=GND}
C {devices/vsource.sym} 5690 -7220 0 0 {name=VB5 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 5690 -7250 0 0 {name=VB6 sig_type=std_logic lab=A[0]}
C {devices/gnd.sym} 5690 -7190 0 0 {name=l67 lab=GND}
C {devices/vsource.sym} 6140 -7220 0 0 {name=VB7 value="pwl=0 1.8 100n 1.8 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 6140 -7250 0 0 {name=VB8 sig_type=std_logic lab=A[2]}
C {devices/gnd.sym} 6140 -7190 0 0 {name=l68 lab=GND}
C {devices/vsource.sym} 6460 -7410 0 0 {name=VB9 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 6460 -7440 0 0 {name=VB10 sig_type=std_logic lab=A[7]}
C {devices/gnd.sym} 6460 -7380 0 0 {name=l69 lab=GND}
C {devices/vsource.sym} 5900 -7400 0 0 {name=VB11 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 5900 -7430 0 0 {name=VB12 sig_type=std_logic lab=A[5]}
C {devices/gnd.sym} 5900 -7370 0 0 {name=l70 lab=GND}
C {devices/vsource.sym} 5730 -7420 0 0 {name=VB13 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 5730 -7450 0 0 {name=VB14 sig_type=std_logic lab=A[4]}
C {devices/gnd.sym} 5730 -7390 0 0 {name=l71 lab=GND}
C {devices/vsource.sym} 6140 -7420 0 0 {name=VB15 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 6140 -7450 0 0 {name=VB16 sig_type=std_logic lab=A[6]}
C {devices/gnd.sym} 6140 -7390 0 0 {name=l72 lab=GND}
C {devices/vsource.sym} 6460 -7610 0 0 {name=VB17 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 6460 -7640 0 0 {name=VB18 sig_type=std_logic lab=A[13]}
C {devices/gnd.sym} 6460 -7580 0 0 {name=l73 lab=GND}
C {devices/vsource.sym} 5900 -7600 0 0 {name=VB19 value="pwl=0 1.8 100n 1.8 " savecurrent=false}
C {devices/lab_pin.sym} 5900 -7630 0 0 {name=VB20 sig_type=std_logic lab=A[11]}
C {devices/gnd.sym} 5900 -7570 0 0 {name=l74 lab=GND}
C {devices/vsource.sym} 5730 -7620 0 0 {name=VB21 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 5730 -7650 0 0 {name=VB22 sig_type=std_logic lab=A[10]}
C {devices/gnd.sym} 5730 -7590 0 0 {name=l75 lab=GND}
C {devices/vsource.sym} 6140 -7620 0 0 {name=VB23 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 6140 -7650 0 0 {name=VB24 sig_type=std_logic lab=A[12]}
C {devices/gnd.sym} 6140 -7590 0 0 {name=l76 lab=GND}
C {devices/vsource.sym} 6460 -7810 0 0 {name=VB25 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 6460 -7840 0 0 {name=VB26 sig_type=std_logic lab=A[9]}
C {devices/gnd.sym} 6460 -7780 0 0 {name=l77 lab=GND}
C {devices/vsource.sym} 5900 -7800 0 0 {name=VB27 value="pwl=0 0 100n 0 " savecurrent=false}
C {devices/lab_pin.sym} 5900 -7830 0 0 {name=VB28 sig_type=std_logic lab=A[15]}
C {devices/gnd.sym} 5900 -7770 0 0 {name=l78 lab=GND}
C {devices/vsource.sym} 5730 -7820 0 0 {name=VB29 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 5730 -7850 0 0 {name=VB30 sig_type=std_logic lab=A[14]}
C {devices/gnd.sym} 5730 -7790 0 0 {name=l79 lab=GND}
C {devices/vsource.sym} 6140 -7820 0 0 {name=VB31 value="pwl=0 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 6140 -7850 0 0 {name=VB32 sig_type=std_logic lab=A[8]}
C {devices/gnd.sym} 6140 -7790 0 0 {name=l80 lab=GND}
C {devices/vsource.sym} 5940 -8260 0 0 {name=VA19 value="pwl=0 0 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 5940 -8290 0 0 {name=p22 sig_type=std_logic lab=A[23]}
C {devices/vsource.sym} 5940 -8160 0 0 {name=VA20 value="pwl=0 1.8 50n 1.8 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 5940 -8190 0 0 {name=p23 sig_type=std_logic lab=A[22]}
C {devices/vsource.sym} 5940 -8060 0 0 {name=VA21 value="pwl=0 1.8 50n 1.8 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 5940 -8090 0 0 {name=p24 sig_type=std_logic lab=A[21]}
C {devices/vsource.sym} 5940 -7960 0 0 {name=VA22 value="pwl=0 1.8 50n 1.8 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 5940 -7990 0 0 {name=VA23 sig_type=std_logic lab=A[20]}
C {devices/gnd.sym} 5940 -7930 0 0 {name=l91 lab=GND}
C {devices/gnd.sym} 5940 -8030 0 0 {name=l93 lab=GND}
C {devices/gnd.sym} 5940 -8130 0 0 {name=l95 lab=GND}
C {devices/gnd.sym} 5940 -8230 0 0 {name=l98 lab=GND}
C {devices/vsource.sym} 6360 -8230 0 0 {name=VA24 value="pwl=0 0 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 6360 -8260 0 0 {name=p25 sig_type=std_logic lab=A[17]}
C {devices/vsource.sym} 6360 -8130 0 0 {name=VA25 value="pwl=0 1.8 50n 1.8 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 6360 -8160 0 0 {name=p26 sig_type=std_logic lab=A[16]}
C {devices/gnd.sym} 6360 -8100 0 0 {name=l103 lab=GND}
C {devices/gnd.sym} 6360 -8200 0 0 {name=l106 lab=GND}
C {devices/vsource.sym} 5941.46728515625 -8378.88671875 0 0 {name=VA29 value="pwl=0 1.8 50n 1.8 50n 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 5941.46728515625 -8408.88671875 0 0 {name=p28 sig_type=std_logic lab=A[28]}
C {devices/gnd.sym} 5941.46728515625 -8348.88671875 0 0 {name=l107 lab=GND}
C {devices/vsource.sym} 6361.46728515625 -8358.88671875 0 0 {name=VA30 value="pwl=0 1.8 50n 1.8 50n 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 6361.46728515625 -8388.88671875 0 0 {name=p29 sig_type=std_logic lab=A[18]}
C {devices/gnd.sym} 6361.46728515625 -8328.88671875 0 0 {name=l108 lab=GND}
C {devices/vsource.sym} 5941.46728515625 -8528.88671875 0 0 {name=VA31 value="pwl=0 1.8 50n 1.8 50n 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 5941.46728515625 -8558.88671875 0 0 {name=p30 sig_type=std_logic lab=A[29]}
C {devices/gnd.sym} 5941.46728515625 -8498.88671875 0 0 {name=l109 lab=GND}
C {devices/vsource.sym} 6351.46728515625 -8498.88671875 0 0 {name=VA32 value="pwl=0 1.8 50n 1.8 50n 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 6351.46728515625 -8528.88671875 0 0 {name=p31 sig_type=std_logic lab=A[30]}
C {devices/gnd.sym} 6351.46728515625 -8468.88671875 0 0 {name=l110 lab=GND}
C {devices/vsource.sym} 6131.46728515625 -8038.88671875 0 0 {name=VA38 value="pwl=0 1.8 50n 1.8 50n 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 6131.46728515625 -8068.88671875 0 0 {name=p36 sig_type=std_logic lab=A[19]}
C {devices/gnd.sym} 6131.46728515625 -8008.88671875 0 0 {name=l117 lab=GND}
C {devices/vsource.sym} 6660 -8320 0 0 {name=VA39 value="pwl=0 0 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 6660 -8350 0 0 {name=p37 sig_type=std_logic lab=A[27]}
C {devices/vsource.sym} 6660 -8220 0 0 {name=VA40 value="pwl=0 1.8 50n 1.8 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 6660 -8250 0 0 {name=p38 sig_type=std_logic lab=A[26]}
C {devices/vsource.sym} 6660 -8120 0 0 {name=VA41 value="pwl=0 1.8 50n 1.8 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 6660 -8150 0 0 {name=p39 sig_type=std_logic lab=A[25]}
C {devices/vsource.sym} 6660 -8020 0 0 {name=VA42 value="pwl=0 1.8 50n 1.8 50n 0" savecurrent=false}
C {devices/lab_pin.sym} 6660 -8050 0 0 {name=VA43 sig_type=std_logic lab=A[24]}
C {devices/gnd.sym} 6660 -7990 0 0 {name=l118 lab=GND}
C {devices/gnd.sym} 6660 -8090 0 0 {name=l119 lab=GND}
C {devices/gnd.sym} 6660 -8190 0 0 {name=l120 lab=GND}
C {devices/gnd.sym} 6660 -8290 0 0 {name=l121 lab=GND}
C {devices/vsource.sym} 6621.46728515625 -8418.88671875 0 0 {name=VA44 value="pwl=0 1.8 50n 1.8 50n 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 6621.46728515625 -8448.88671875 0 0 {name=p40 sig_type=std_logic lab=A[31]}
C {devices/gnd.sym} 6621.46728515625 -8388.88671875 0 0 {name=l122 lab=GND}
C {devices/vsource.sym} 7191.46728515625 -7208.88671875 0 0 {name=VDD value=1.8 savecurrent=false}
C {devices/lab_pin.sym} 7191.46728515625 -7238.88671875 0 0 {name=VDD1 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 7191.46728515625 -7178.88671875 0 0 {name=VDD2 lab=GND}
C {devices/code_shown.sym} 7280 -7335 0 0 {name=S1 only_toplevel=false value=".tran 0.01n 300n
.save all"}
C {sky130_fd_pr/corner.sym} 7265 -7265 0 0 {name=CORNER only_toplevel=true corner=tt}
C {devices/vsource.sym} 5030 -7130 0 0 {name=VA17 value="pwl=0 1.8 100n 1.8 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 5030 -7160 0 0 {name=p27 sig_type=std_logic lab=S}
C {devices/vsource.sym} 5030 -7030 0 0 {name=VA18 value="pwl=0 1.8 50n 1.8 50n 1.8 100n 1.8" savecurrent=false}
C {devices/lab_pin.sym} 5030 -7060 0 0 {name=p46 sig_type=std_logic lab=S0}
C {devices/vsource.sym} 5030 -6930 0 0 {name=VA26 value="pwl=0 1.8 50n 1.8 50n 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 5030 -6960 0 0 {name=VA27 sig_type=std_logic lab=S1}
C {devices/gnd.sym} 5030 -6900 0 0 {name=l81 lab=GND}
C {devices/gnd.sym} 5030 -7000 0 0 {name=l82 lab=GND}
C {devices/gnd.sym} 5030 -7100 0 0 {name=l83 lab=GND}
C {devices/vsource.sym} 5420 -6930 0 0 {name=VA1 value="pwl=0 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 5420 -6960 0 0 {name=VA2 sig_type=std_logic lab=l}
C {devices/gnd.sym} 5420 -6900 0 0 {name=l84 lab=GND}
C {devices/ipin.sym} 3990 -7800 1 0 {name=p1 sig_type=std_logic lab=S2}
C {devices/vsource.sym} 5030 -6820 0 0 {name=VA3 value="pwl=0 1.8 50n 1.8 50n 0 100n 0" savecurrent=false}
C {devices/lab_pin.sym} 5030 -6850 0 0 {name=VA4 sig_type=std_logic lab=S2}
C {devices/gnd.sym} 5030 -6790 0 0 {name=l85 lab=GND}
